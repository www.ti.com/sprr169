# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_4a.brd (continued)
## Nets (continued)
AM335X_XDMA_EVENT_INTR1: R77.2(P2) R228.2(P2) R250.2(P2) R315.2(P2) R351.1(P1) TP32.1 U2.D14(XDMA_EVENT_INTR1)
CAP_VBB_MPU: C72.1 U2.C10(CAP_VBB_MPU)
CAP_VDD_SRAM_CORE: C60.1 U2.D9(CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU: C71.1 U2.D11(CAP_VDD_SRAM_MPU)
COM_AUD_CLK: J11.52 R338.2(P2)
COM_AUD_FSYNC: J11.54 R339.2(P2)
COM_AUD_IN: J11.56 R340.2(P2)
COM_AUD_OUT: J11.58 R341.2(P2)
COM_BTRST: J11.89 R353.1(P1)
COM_BTUARTCTS: J11.70 R344.2(P2)
COM_BTUARTDEBUG: J11.76 TP45.1
COM_BTUARTRTS: J11.72 R345.2(P2)
COM_BTUARTRX: J11.68 R343.2(P2)
COM_BTUARTTX: J11.66 R342.2(P2)
COM_GNSS_PPS_OUT: J11.50 U14.10(2B2)
COM_GNSS_TIME_STAMP: J11.48 U13.10(2B2)
COM_SDIO_CLK: J11.20 R334.1(P1) R485.2(P2)
COM_SDIO_CMD: J11.24 R333.1(P1) R486.2(P2)
COM_SDIO_D0: J11.26 R332.1(P1) R487.2(P2)
COM_SDIO_D1: J11.28 R331.1(P1) R488.2(P2)
COM_SDIO_D2: J11.30 R330.1(P1) R489.2(P2)
COM_SDIO_D3: J11.32 R329.1(P1) R490.2(P2)
COM_SLOW_CLK: J11.1 U15.12(1B2)
COM_WL_IRQ: J11.34 R337.2(P2)
COM_WL_RS232_RX: J11.13 TP43.1
COM_WL_RS232_TX: J11.11 TP42.1
COM_WL_RST: J11.4 R327.2(P2)
COM_WL_UART_DBG: J11.15 TP44.1
COMAUD_CLK: R338.1(P1) U14.13(1B1)
COMAUD_FSYNC: R339.1(P1) U13.11(2B1)
COMAUD_IN: R340.1(P1) U14.12(1B2)
COMAUD_OUT: R341.1(P1) U14.11(2B1)
COMBTRST: R353.2(P2) U15.10(2B2)
COMBTUARTCTS: R344.1(P1) U16.12(1B2)
COMBTUARTRTS: R345.1(P1) U16.10(2B2)
COMBTUARTRX: R343.1(P1) U16.13(1B1)
COMBTUARTTX: R342.1(P1) U16.11(2B1)
COMWL_IRQ: R337.1(P1) U13.13(1B1)
COMWL_RST: R327.1(P1) U15.13(1B1)
DDR_A0: R18.2(P2) U8.H8(A0) U31.H8(A0)
DDR_A1: R21.2(P2) U8.H3(A1) U31.H3(A1)
DDR_A2: R31.2(P2) U8.H7(A2) U31.H7(A2)
DDR_A3: R33.2(P2) U8.J2(A3) U31.J2(A3)
DDR_A4: R34.2(P2) U8.J8(A4) U31.J8(A4)
DDR_A5: R35.2(P2) U8.J3(A5) U31.J3(A5)
DDR_A6: R36.2(P2) U8.J7(A6) U31.J7(A6)
DDR_A7: R37.2(P2) U8.K2(A7) U31.K2(A7)
DDR_A8: R38.2(P2) U8.K8(A8) U31.K8(A8)
DDR_A9: R39.2(P2) U8.K3(A9) U31.K3(A9)
DDR_A10: R40.2(P2) U8.H2(A10) U31.H2(A10)
DDR_A11: R41.2(P2) U8.K7(A11) U31.K7(A11)
DDR_A12: R42.2(P2) U8.L2(A12) U31.L2(A12)
DDR_A13: R43.2(P2) U8.L8(A13) U31.L8(A13)
DDR_A14: R44.2(P2) U8.L3(A14) U31.L3(A14)
DDR_BA0: R47.2(P2) U8.G2(BA0) U31.G2(BA0)
DDR_BA1: R49.2(P2) U8.G3(BA1) U31.G3(BA1)
DDR_BA2: R549.2(P2) U8.G1(BA2) U31.G1(BA2)
DDR_CASN: R13.2(P2) U8.G7(CASN) U31.G7(CASN)
DDR_CKE: R537.2(P2) U8.F2(CKE) U31.F2(CKE)
DDR_CLK: R11.2(P2) U8.E8(CK) U31.E8(CK)
DDR_CLKN: R12.2(P2) U8.F8(CKN) U31.F8(CKN)
DDR_CSN: R538.2(P2) U8.G8(CSN) U31.G8(CSN)
DDR_D0: R429.2(P2) U8.C8(DQ0)
DDR_D1: R522.2(P2) U8.C2(DQ1)
DDR_D2: R523.2(P2) U8.D7(DQ2)
DDR_D3: R524.2(P2) U8.D3(DQ3)
DDR_D4: R525.2(P2) U8.D1(DQ4)
DDR_D5: R526.2(P2) U8.D9(DQ5)
DDR_D6: R527.2(P2) U8.B1(DQ6)
DDR_D7: R528.2(P2) U8.B9(DQ7)
DDR_D8: R529.2(P2) U31.C8(DQ0)
DDR_D9: R530.2(P2) U31.C2(DQ1)
DDR_D10: R531.2(P2) U31.D7(DQ2)
DDR_D11: R532.2(P2) U31.D3(DQ3)
DDR_D12: R533.2(P2) U31.D1(DQ4)
DDR_D13: R534.2(P2) U31.D9(DQ5)
DDR_D14: R535.2(P2) U31.B1(DQ6)
DDR_D15: R536.2(P2) U31.B9(DQ7)
DDR_DQM0: R16.2(P2) U8.B3(DM)
DDR_DQM1: R19.2(P2) U31.B3(DM)
DDR_DQS0: R17.2(P2) U8.B7(DQS)
DDR_DQS1: R20.2(P2) U31.B7(DQS)
DDR_DQSN0: R539.2(P2) U8.A8(DQSN)
DDR_DQSN1: R540.2(P2) U31.A8(DQSN)
DDR_ODT: R543.2(P2) U8.F9(ODT) U31.F9(ODT)
DDR_RASN: R14.2(P2) U8.F7(RASN) U31.F7(RASN)
DDR_VREF: R541.2(P2) R542.2(P2) U2.J4(DDR_VREF) U8.E2(VREF) U31.E2(VREF)
DDR_WEN: R15.2(P2) U8.F3(WEN) U31.F3(WEN)
EMU2: J2.17(EMU2) R76.1(P1)
EMU3: J2.18(EMU3) R77.1(P1)
EMU4: J2.19(EMU4) R78.1(P1)
EMU_RSTN: C260.1 J2.15(SRST) R517.1(P1)
ENZ_KALDO_1P8V: R48.2(P2) U2.B4(RTC_KALDO_ENN)
ETH_INTN: R404.1(P1) R409.1(P1) U25.5(INT)
ETH_MDIO_CLK: R407.2(P2) R433.1(P1) U25.1(MDC)
ETH_MDIO_DATA: R408.1(P1) R434.1(P1) U25.48(MDIO)
ETH_RBIAS: R406.2(P2) U25.9(RBIAS)
ETH_REFCLK: R432.1(P1) U25.25(CLK_25M)
ETH_RESETN: R391.1(P1) U25.2(R\S\T\) U26.4(Y)
ETH_RXCLK: R422.2(P2) R423.1(P1) U25.33(RX_CLK)
ETH_RXD0: R411.2(P2) R424.1(P1) U25.31(RXD0)
ETH_RXD1: R413.2(P2) R425.1(P1) U25.30(RXD1)
ETH_RXD2: R419.2(P2) R427.1(P1) U25.28(RXD2)
ETH_RXD3: R426.2(P2) R428.1(P1) U25.27(RXD3)
ETH_RXDV: R414.2(P2) R430.1(P1) U25.32(RX_DV)
ETH_TXCLK: R415.1(P1) U25.35(GTX_CLK)
ETH_TXD0: R416.1(P1) U25.36(TXD0)
ETH_TXD1: R417.1(P1) U25.37(TXD1)
ETH_TXD2: R418.1(P1) U25.38(TXD2)
ETH_TXD3: R420.1(P1) U25.39(TXD3)
ETH_TXEN: R421.1(P1) U25.34(TX_EN)
ETHER_D0N: J15.10 U25.12(TRXN0)
ETHER_D0P: J15.9 U25.11(TRXP0)
ETHER_D1N: J15.8 U25.15(TRXN1)
ETHER_D1P: J15.7 U25.14(TRXP1)
ETHER_D2N: J15.6 U25.18(TRXN2)
ETHER_D2P: J15.5 U25.17(TRXP2)
ETHER_D3N: J15.4 U25.21(TRXN3)
ETHER_D3P: J15.3 U25.20(TRXP3)
EXP0_P25: J3.25 R178.2(P2)
EXP3_P9: J6.9 TP35.1
EXP_ECAP0_IN_PWM0_OUT: J5.19 R210.2(P2)
EXP_GPMC_ADVN_ALE: J4.26 R182.1(P1)
EXP_GPMC_BE0N_CLE: J4.28 R184.1(P1)
EXP_GPMC_BE1N: J5.2 R186.1(P1)
EXP_GPMC_CLK: J4.23 R181.1(P1)
EXP_GPMC_CS0N: J4.25 R183.1(P1)
EXP_GPMC_CS3N: J5.4 R187.1(P1)
EXP_GPMC_OEN_REN: J5.6 R189.1(P1)
EXP_GPMC_WAIT: J4.19 R179.1(P1)
EXP_GPMC_WEN: J5.8 R191.1(P1)
EXP_GPMC_WPN: J4.21 R180.1(P1)
EXP_I2C1_SCL: J3.24 R176.1(P1)
EXP_I2C1_SDA: J3.23 R177.2(P2)
EXP_MII1_COL: J5.34 R231.1(P1)
EXP_MII1_CRS: J5.36 R235.1(P1)
EXP_MII1_RXERR: J5.38 R237.1(P1)
EXP_MMC0_CLK: J5.12 R197.1(P1)
EXP_MMC0_CMD: J5.14 R200.1(P1)
EXP_MMC0_DAT0: J5.16 R204.1(P1)
EXP_MMC0_DAT1: J5.22 R212.1(P1)
EXP_MMC0_DAT2: J5.24 R215.1(P1)
EXP_MMC0_DAT3: J5.26 R219.1(P1)
EXP_MMC1_CLK: J3.21 R175.2(P2)
EXP_MMC1_CMD: J3.19 R173.2(P2)
EXP_MMC1_DAT0: J3.17 R171.2(P2)
EXP_MMC1_DAT1: J3.15 R169.2(P2)
EXP_MMC1_DAT2: J3.13 R167.2(P2)
EXP_MMC1_DAT3: J3.11 R165.2(P2)
EXP_MMC1_DAT4: J3.9 R163.2(P2)
EXP_MMC1_DAT5: J3.7 R161.2(P2)
EXP_MMC1_DAT6: J3.5 R159.2(P2)
EXP_MMC1_DAT7: J3.3 R157.2(P2)
EXP_PB_POWERON: J4.12 R63.2(P2)
EXP_RMII1_REFCLK: J5.3 R188.2(P2)
EXP_SPI0_CLK: J5.13 R201.2(P2)
EXP_SPI0_CS1: J5.17 R208.2(P2)
EXP_SPI0_D0: J5.15 R205.2(P2)
EXP_UART0_CTSN: J5.21 R213.2(P2)
EXP_UART0_RTSN: J5.23 R216.2(P2)
EXP_UART0_RXD: J5.25 R220.2(P2)
EXP_UART0_TXD: J5.27 R222.2(P2)
EXP_UART1_CTSN: J5.29 R225.2(P2)
EXP_UART1_RTSN: J5.31 R229.2(P2)
EXP_UART1_RXD: J5.33 R232.2(P2)
EXP_UART1_TXD: J5.35 R236.2(P2)
EXP_WAKEUP: J5.18 R207.1(P1)
EXP_XDMA_EVENT_INTR0: J5.28 R221.1(P1)
EXP_XDMA_EVENT_INTR1: J5.32 R228.1(P1)
GPMC_A0: J6.2 R193.1(P1)
GPMC_A1: J6.4 R196.1(P1)
GPMC_A2: J6.6 R198.1(P1)
GPMC_A3: J6.8 R202.1(P1)
GPMC_A4: J6.10 R206.1(P1)
GPMC_A5: J6.12 R209.1(P1)
GPMC_A6: J6.16 R214.1(P1)
GPMC_A7: J6.18 R217.1(P1)
GPMC_A8: J6.22 R223.1(P1)
GPMC_A9: J6.24 R226.1(P1)
GPMC_A10: J6.26 R230.1(P1)
GPMC_A11: J6.28 R233.1(P1)
HDMI_AUDBCLK: R316.1(P1) U10.45(SCK)
HDMI_AUDD0: R318.1(P1) U10.41(SD0)
HDMI_AUDD1: R319.1(P1) U10.40(SD1)
HDMI_AUDD2: R320.1(P1) U10.39(SD2)
HDMI_AUDD3: R321.1(P1) U10.37(SD3)
HDMI_AUDFSX: R317.1(P1) U10.44(WS)
HDMI_AUDMCLK: R315.1(P1) U10.38(MCLK)
HDMI_AVCC12: C153.1 C154.1 C244.1 FB13.1 U10.60(AVCC12#60) U10.66(AVCC12#66)
HDMI_CEC: R277.1(P1) U10.71(CEC_A) U11.1(CEC_A)
HDMI_CEC_D: R296.1(P1) U10.50(CEC_D)
HDMI_CLK+: J10.10(CLK+) U10.59(TXC+) U11.16(TMDS_CK+)
HDMI_CLK-: J10.12(CLK-) U10.58(TXC-) U11.15(TMDS_CK-)
HDMI_CT_HPD: R322.2(P2) R323.1(P1) U11.12(CT_HPD)
HDMI_CVCC12: C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 FB11.1 U10.5(CVCC12#5) U10.12(CVCC12#12) U10.26(CVCC12#26) U10.42(CVCC12#42) U10.47(CVCC12#47) U10.53(CVCC12#53)
HDMI_D0: R278.1(P1) U10.32(VDATA_IN0)
HDMI_D1: R279.1(P1) U10.31(VDATA_IN1)
HDMI_D2: R280.1(P1) U10.30(VDATA_IN2)
HDMI_D3: R281.1(P1) U10.29(VDATA_IN3)
HDMI_D4: R282.1(P1) U10.28(VDATA_IN4)
HDMI_D5: R283.1(P1) U10.27(VDATA_IN5)
HDMI_D6: R284.1(P1) U10.25(VDATA_IN6)
HDMI_D7: R285.1(P1) U10.24(VDATA_IN7)
HDMI_D8: R286.1(P1) U10.23(VDATA_IN8)
HDMI_D9: R287.1(P1) U10.20(VDATA_IN9)
HDMI_D10: R288.1(P1) U10.19(VDATA_IN10)
HDMI_D11: R289.1(P1) U10.18(VDATA_IN11)
HDMI_D12: R290.1(P1) U10.17(VDATA_IN12)
HDMI_D13: R291.1(P1) U10.16(VDATA_IN13)
HDMI_D14: R293.1(P1) U10.15(VDATA_IN14)
HDMI_D15: R294.1(P1) U10.14(VDATA_IN15)
HDMI_D16: R295.1(P1) U10.13(VDATA_IN16)
HDMI_D17: R297.1(P1) U10.11(VDATA_IN17)
HDMI_D18: R298.1(P1) U10.10(VDATA_IN18)
HDMI_D19: R299.1(P1) U10.9(VDATA_IN19)
HDMI_D20: R300.1(P1) U10.8(VDATA_IN20)
HDMI_D21: R301.1(P1) U10.7(VDATA_IN21)
HDMI_D22: R302.1(P1) U10.6(VDATA_IN22)
HDMI_D23: R303.1(P1) U10.4(VDATA_IN23)
HDMI_DE: R312.1(P1) U10.33(DE)
HDMI_EXTSWING: R292.2(P2) U10.56(EXT_SWING)
HDMI_HPLG: R569.2(P2) U10.54(HPD) U11.4(HPD_A)
HDMI_HSYNC: R311.1(P1) U10.34(HSYNC)
HDMI_I2C_SCL: R313.1(P1) U10.1(CSCL)
HDMI_I2C_SDA: R314.1(P1) U10.2(CSDA)
HDMI_I2CSCL: R567.1(P1) U10.49(DSCL) U11.2(SCL_A)
HDMI_I2CSDA: R568.1(P1) U10.48(DSDA) U11.3(SDA_A)
HDMI_INTN: R324.1(P1) R570.1(P1) U10.52(INT)
HDMI_IOVCC: C150.1 C151.1 C152.1 FB12.1 U10.3(IOVCC#3) U10.21(IOVCC#21) U10.46(IOVCC#46)
HDMI_LSOE: R322.1(P1) U11.5(LS_OE)
HDMI_PCLK: R307.1(P1) U10.22(IDCK)
HDMI_TX0+: J10.7(DAT0+) U10.62(TX0+) U11.18(TMDS_D0+)
HDMI_TX0-: J10.9(DAT0-) U10.61(TX0-) U11.17(TMDS_D0-)
HDMI_TX1+: J10.4(DAT1+) U10.65(TX1+) U11.21(TMDS_D1+)
HDMI_TX1-: J10.6(DAT1-) U10.64(TX1-) U11.20(TMDS_D1-)
HDMI_TX2+: J10.1(DAT2+) U10.68(TX2+) U11.23(TMDS_D2+)
HDMI_TX2-: J10.3(DAT2-) U10.67(TX2-) U11.22(TMDS_D2-)
HDMI_VSYNC: R305.1(P1) U10.35(VSYNC)
HDMICONN_CEC: J10.13(CEC) U11.7(CEC_B)
HDMICONN_HPLG: J10.19(HPLG) R304.2(P2) U11.10(HPD_B)
HDMICONN_I2CSCL: J10.15(SCL) R276.1(P1) U11.8(SCL_B)
HDMICONN_I2CSDA: J10.16(SDA) R275.1(P1) U11.9(SDA_B)
JTAG_EMU0: J2.13(EMU0) R71.1(P1) U2.C14(EMU0///////GPIO3_7)
JTAG_EMU1: J2.14(EMU1) R70.1(P1) U2.B14(EMU1///////GPIO3_8)
JTAG_TCK: R74.2(P2) R75.2(P2) U2.A12(TCK)
JTAG_TDI: J2.3(TDI) U2.B11(TDI)
JTAG_TDO: J2.7(TDO) U2.A11(TDO)
JTAG_TMS: J2.1(TMS) U2.C11(TMS)
JTAG_TRSTN: J2.2(TRSTN) R79.2(P2) U2.B10(TRSTN)
LCD_DATA0: J7.4 R240.1(P1)
LCD_DATA1: J7.3 R241.1(P1)
LCD_DATA2: J7.6 R245.1(P1)
LCD_DATA3: J7.5 R246.1(P1)
LCD_DATA4: J7.8 R251.1(P1)
LCD_DATA5: J7.7 R252.1(P1)
LCD_DATA6: J8.15 R270.1(P1)
LCD_DATA7: J8.9 R259.1(P1)
LCD_DATA8: J8.11 R262.1(P1)
LCD_DATA9: J8.13 R266.1(P1)
LCD_DATA10: J7.10 R256.1(P1)
LCD_DATA11: J7.16 R267.1(P1)
LCD_DATA12: J7.9 R257.1(P1)
LCD_DATA13: J8.10 R258.1(P1)
LCD_DATA14: J7.12 R260.1(P1)
LCD_DATA15: J8.7 R254.1(P1)
LCD_DATA16: J8.8 R253.1(P1)
LCD_DATA17: J8.5 R248.1(P1)
LCD_DATA18: J8.6 R247.1(P1)
LCD_DATA19: J7.13 R264.1(P1)
LCD_DATA20: J8.3 R243.1(P1)
LCD_DATA21: J8.4 R242.1(P1)
LCD_DATA22: J7.14 R263.1(P1)
LCD_DATA23: J7.11 R261.1(P1)
LCD_DEN: J8.17 R273.1(P1)
LCD_HSYNC: J8.18 R272.1(P1)
LCD_I2C_SCL: J8.14 R265.1(P1)
LCD_I2C_SDA: J7.15 R268.1(P1)
LCD_PCLK: J8.16 R269.1(P1)
LCD_VSYNC: J7.17 R271.1(P1)
LCDA_PIN18: J7.18 R274.2(P2)
LDO_VRTC: C113.1 R557.2(P2) U5.5(OUT)
MCASP0_ACLKR: J6.17 R218.1(P1)
MCASP0_ACLKX: J6.1 R194.2(P2)
MCASP0_AHCLKR: J6.13 R211.2(P2)
MCASP0_AHCLKX: J6.27 R234.1(P1)
MCASP0_AXR0: J6.7 R203.2(P2)
MCASP0_AXR1: J6.23 R227.1(P1)
MCASP0_FSR: J6.21 R224.1(P1)
MCASP0_FSX: J6.5 R199.2(P2)
MMC2_CLK: R485.1(P1) U28.13(CLKB1)
MMC2_CMD: R486.1(P1) U28.12(CMDB1)
MMC2_D0: R487.1(P1) U28.14(DAT0B1)
MMC2_D1: R488.1(P1) U28.15(DAT1B1)
MMC2_D2: R489.1(P1) U28.8(DAT2B1)
MMC2_D3: R490.1(P1) U28.10(DAT3B1)
MMC2_SDIO_SEL: R515.1(P1) R516.2(P2) U28.24(SEL)
MMC_CD: J13.15(CD) R378.1(P1) R380.1(P1) U21.3(IO1)
MMC_CLK: J13.5(#5_MMC+/MMCM/RSMMC/MMC/SD) J13.20(#5_MINISD) R398.1(P1) U19.1(IO1)
MMC_CMD: J13.2(#2_MMC+/MMCM/RSMMC/MMC/SD) J13.17(#2_MINISD) R366.1(P1) R397.1(P1) U19.7(IO5)
MMC_D0: J13.7(#7_MMC+/MMCM/RSMMC/MMC/SD) J13.22(#7_MINISD) R367.1(P1) R399.1(P1) U19.2(IO2)
MMC_D1: J13.8(#8_MMC+/MMCM/SD) J13.23(#8_MINISD) R368.1(P1) R400.1(P1) U19.3(IO3)
MMC_D2: J13.9(#9_MMC+/MMCM/SD) J13.24(#9_MINISD) R369.1(P1) R401.1(P1) U19.6(IO4)
MMC_D3: J13.1(#1_MMC+/MMCM/RSMMC/MMC/SD) J13.16(#1_MINISD) R365.1(P1) R396.1(P1) U19.8(IO6)
MMC_D4: J13.10(#10_MMC+/MMCM) R370.1(P1) U20.1(IO1)
MMC_D5: J13.11(#11_MMC+/MMCM) R371.1(P1) U20.2(IO2)
MMC_D6: J13.12(#12_MMC+/MMCM) R372.1(P1) U20.7(IO5)
MMC_D7: J13.13(#13_MMC+/MMCM) R373.1(P1) U20.8(IO6)
MMC_WP: J13.14(SD_WP) R379.1(P1) U21.5(IO2)
MVRK_GPIO1_D0: J16.2 R437.1(P1)
MVRK_GPIO1_D1: J16.4 R439.1(P1)
MVRK_GPIO1_D2: J16.6 R440.1(P1)
MVRK_GPIO1_D3: J16.8 R441.1(P1)
MVRK_GPIO1_D4: J16.10 R442.1(P1)
MVRK_GPIO1_D5: J16.12 R444.1(P1)
MVRK_GPIO1_D6: J16.14 R446.1(P1)
MVRK_GPIO1_D7: J16.16 R447.1(P1)
MVRK_GPIO1_LATCHEN: J16.20 R450.1(P1)
MVRK_I2C_SCL: J16.11 R443.2(P2)
MVRK_I2C_SDA: J16.13 R445.2(P2)
MVRK_SPI_CS: J16.23 R452.2(P2)
MVRK_SPI_SCLK: J16.17 R448.2(P2)
MVRK_SPI_SIMO: J16.21 R451.2(P2)
MVRK_SPI_SOMI: J16.19 R449.2(P2)
MVRK_UART_RXD: J16.3 R438.2(P2)
MVRK_UART_TXD: J16.1 R436.2(P2)
NAND_ADVN_ALE: R137.1(P1) U9.17(ALE)
NAND_BE0N_CLE: R136.1(P1) U9.16(CLE)
NAND_CSN: R132.1(P1) R135.1(P1) U9.9(\\C\E\)
NAND_D0: R140.1(P1) U9.29(I/O0)
NAND_D1: R141.1(P1) U9.30(I/O1)
NAND_D2: R142.1(P1) U9.31(I/O2)
NAND_D3: R143.1(P1) U9.32(I/O3)
NAND_D4: R144.1(P1) U9.41(I/O4)
NAND_D5: R145.1(P1) U9.42(I/O5)
NAND_D6: R146.1(P1) U9.43(I/O6)
NAND_D7: R147.1(P1) U9.44(I/O7)
NAND_D8: R148.1(P1) U9.26(NC_IO8)
NAND_D9: R149.1(P1) U9.27(NC_IO9)
NAND_D10: R150.1(P1) U9.28(NC_IO10)
NAND_D11: R151.1(P1) U9.33(NC_IO11)
NAND_D12: R152.1(P1) U9.40(NC_IO12)
NAND_D13: R153.1(P1) U9.45(NC_IO13)
NAND_D14: R154.1(P1) U9.46(NC_IO14)
NAND_D15: R155.1(P1) U9.47(NC_IO15)
NAND_OEN: R134.1(P1) U9.8(\\R\E)
NAND_WAIT: R131.1(P1) R133.1(P1) U9.7(R/\B\)
NAND_WEN: R138.1(P1) U9.18(\\W\E)
NAND_WPN: R130.1(P1) R139.1(P1) U9.19(\\W\P)
PB_INTERRUPT: C118.1 R113.2(P2) R156.1(P1) R560.1(P1)
PHY_LED_10/100N: C207.1 U25.26(LED_LINK10_100)
PHY_LED_1000N: C206.1 R392.1 R431.2(P2) U25.24(LED_LINK1000)
PHY_LED_ACTN: C205.1 R390.1 R435.2(P2) U25.23(LED_ACT)
PHY_PPS/GPIO: R395.1(P1) U25.22(PPS)
PM_ALERT: J17.4 R455.1(P1) U27.3(ALERT) U32.3(ALERT)
PM_VDDAADCN: C370.2 J27.2 R501.3(SENS1)
PM_VDDAADCP: C370.1 J27.1 R501.4(SENS2)
PM_VDDCOREN: C353.2 R32.4(SENS2) U27.9(VIN-)
PM_VDDCOREP: C353.1 R32.3(SENS1) U27.10(VIN+)
PM_VDDMPUN: R46.4(SENS2) U32.9(VIN-)
PM_VDDMPUP: R46.3(SENS1) U32.10(VIN+)
PM_VDDSDDRN: C361.2 J20.2 R508.4(SENS2)
PM_VDDSDDRP: C361.1 J20.1 R508.3(SENS1)
PM_VDDSHV1N: C363.2 J26.2 R493.3(SENS1)
PM_VDDSHV1P: C363.1 J26.1 R493.4(SENS2)
PM_VDDSHV2N: C372.2 J38.2 R545.3(SENS1)
PM_VDDSHV2P: C372.1 J38.1 R545.4(SENS2)
PM_VDDSHV3N: C373.2 J39.2 R546.3(SENS1)
PM_VDDSHV3P: C373.1 J39.1 R546.4(SENS2)
PM_VDDSHV4N: C364.2 J30.2 R494.3(SENS1)
PM_VDDSHV4P: C364.1 J30.1 R494.4(SENS2)
PM_VDDSHV5N: C365.2 J32.2 R495.3(SENS1)
PM_VDDSHV5P: C365.1 J32.1 R495.4(SENS2)
PM_VDDSHV6N: C366.2 J34.2 R496.3(SENS1)
PM_VDDSHV6P: C366.1 J34.1 R496.4(SENS2)
PM_VDDSN: C368.2 J21.2 R498.3(SENS1)
PM_VDDSOSCN: C371.2 J29.2 R506.3(SENS1)
PM_VDDSOSCP: C371.1 J29.1 R506.4(SENS2)
PM_VDDSP: C368.1 J21.1 R498.4(SENS2)
PM_VDDSRTCN: C367.2 J35.2 R505.3(SENS1)
PM_VDDSRTCP: C367.1 J35.1 R505.4(SENS2)
PM_VPLLCRLCDN: C369.2 J24.2 R503.3(SENS1)
PM_VPLLCRLCDP: C369.1 J24.1 R503.4(SENS2)
PM_VPLLDDRN: C360.2 J33.2 R507.4(SENS2)
PM_VPLLDDRP: C360.1 J33.1 R507.3(SENS1)
PM_VPLLMPUN: C356.2 J22.2 R497.4(SENS2)
PM_VPLLMPUP: C356.1 J22.1 R497.3(SENS1)
PM_VSRAMCOREN: C362.2 J23.2 R500.4(SENS2)
PM_VSRAMCOREP: C362.1 J23.1 R500.3(SENS1)
PM_VSRAMMPUN: C357.2 J25.2 R499.4(SENS2)
PM_VSRAMMPUP: C357.1 J25.1 R499.3(SENS1)
PM_VUSB1_8VN: C358.2 J28.2 R502.4(SENS2)
PM_VUSB1_8VP: C358.1 J28.1 R502.3(SENS1)
PM_VUSB3_3VN: C359.2 J31.2 R504.4(SENS2)
PM_VUSB3_3VP: C359.1 J31.1 R504.3(SENS1)
PMIC_DELAYEDRTCPORZ: R3.1(P1) U1.2(B)
PMIC_GPIO: C114.1 R3.2(P2) R54.1(P1) R57.2(P2) R69.1(P1)
PMIC_I2C_SCL: R55.1(P1) R551.1(P1) U4.9(SCL_SCK)
PMIC_I2C_SDA: R56.1(P1) R550.1(P1) U4.8(SDA_SDI)
PMIC_INTN: R61.1(P1) R66.1(P1) U4.45(INT1)
PMIC_PWR_EN: R178.1(P1) R478.2(P2) R556.2(P2) U2.C6(PMIC_POWER_EN)
PMIC_PWRHOLD: R556.1(P1) U4.1(PWRHOLD)
PMIC_RESETOUTN: R1.2(P2) R65.2(P2) U4.40(NRESPWRON)
PMIC_SLEEP: R62.1(P1) U4.37(SLEEP)
PMICSR_I2C_SCL: R58.1(P1) U4.11(SCLSR_EN1)
PMICSR_I2C_SDA: R59.1(P1) U4.10(SDASR_EN2)
PWR_SMPS1: L2.1 U4.35(SW1)
PWR_SMPS1_FB: R561.2(P2) R562.2(P2) U4.32(VFB1)
PWR_SMPS2: L3.1 U4.42(SW2)
PWR_SMPS3: L8.1 U4.31(SW3)
PWR_SWIO: L4.1 U4.14(SWIO)
PWR_VAUX1: C109.1 R474.1(P1) U4.46(VAUX1)
PWR_VAUX2: C110.1 R475.1(P1) U4.48(VAUX2)
PWR_VAUX33: C108.1 R463.2(P2) R466.1(P1) U4.4(VAUX33)
PWR_VDAC: C101.1 R471.1(P1) U4.22(VDAC)
PWR_VDD1_SMPS: C237.1 L2.2 R469.2(P2) R562.1(P1)
PWR_VDD2_SMPS: C239.1 L3.2 R468.2(P2) U4.44(VFB2)
PWR_VDD3_SMPS: L8.2 R470.2(P2) U4.30(VFB3)
PWR_VDDIO: R465.2(P2) R466.2(P2) U4.12(VDDIO)
PWR_VDIG1: C104.1 R464.2(P2) U4.7(VDIG1)
PWR_VDIG2: C103.1 R476.2(P2) U4.5(VDIG2)
PWR_VIO_SMPS: C241.1 L4.2 R465.1(P1) R467.2(P2) U4.16(VFBIO)
PWR_VMMC: C107.1 R477.2(P2) U4.2(VMMC)
PWR_VPLL: C102.1 R473.1(P1) U4.24(VPLL)
PWRMON_I2CSCL: J17.1 R453.1(P1) U27.5(SCL) U32.5(SCL)
PWRMON_I2CSDA: J17.2 R454.1(P1) U27.4(SDA) U32.4(SDA)
RS232_CTS: J12.8 U18.8(RIN2)
RS232_RTS: J12.7 U18.7(DOUT2)
RS232_RXD: J12.2 U18.13(RIN1)
RS232_TXD: J12.3 U18.14(DOUT1)
RTC_PORZ: U3.2(B) U33.3(A)
RTCK: J2.9(TCKRTN) R74.1(P1)
SDIO_GPMC_A1: R196.2(P2) U28.18(DAT0B0)
SDIO_GPMC_A2: R198.2(P2) U28.16(DAT1B0)
SDIO_GPMC_A3: R202.2(P2) U28.23(DAT2B0)
SDIO_GPMC_BE1N: R186.2(P2) U28.22(DAT3B0)
SDIO_GPMC_CLK: R181.2(P2) U28.19(CLKB0)
SDIO_GPMC_CS3N: R187.2(P2) U28.20(CMDB0)
SYS_RESETN: J3.26 R6.1(P1) R10.2(P2) R306.1(P1) R517.2(P2) U2.A10(WARMRSTN) U10.51(RESETN) U26.2(A)
SYS_WARMRESETN: C117.1 J4.11 R10.1(P1) SW2.3 SW2.4
TCK: J2.11(TCK) R75.1(P1)
TSC_CLK: J9.5 R250.1(P1)
TSC_GIO0: J9.1 TP38.1
TSC_GIO1: J9.3 TP39.1
TSC_GIO2: J9.8 R255.1(P1)
TSC_I2CSCL: J9.4 R244.1(P1)
TSC_I2CSDA: J9.6 R249.1(P1)
TSC_RSV0: J9.7 TP40.1
TSC_RSV1_VREF: J9.9 TP41.1
UART0_CTSN: R364.1(P1) U18.9(ROUT2)
UART0_RTSN: R362.1(P1) U18.10(DIN2)
UART0_RXD: R363.1(P1) U18.12(ROUT1)
UART0_TXD: R361.1(P1) U18.11(DIN1)
USB0_CONN_DM: J14.2(DM) L5.3 U23.2(D-)
USB0_CONN_DP: J14.3(DP) L5.4 U23.1(D+)
USB0_DM: L5.2 U2.N18(USB0_DM)
USB0_DP: L5.1 U2.N17(USB0_DP)
USB0_ID: J14.4(ID) R381.2(P2) R571.1(P1) U2.P16(USB0_ID) U23.3(ID)
USB0_MEAS_IDN: Q5.G(GATE) R565.1(P1) R566.1(P1)
USB0_OVRCURN: R382.2(P2) R384.2(P2) U22.5(O\C\)
USB1_CONN_DM: J18.2(DM) L6.3 U30.2(D-)
USB1_CONN_DP: J18.3(DP) L6.4 U30.1(D+)
USB1_DM: L6.2 U2.R18(USB1_DM)
USB1_DP: L6.1 U2.R17(USB1_DP)
USB1_ID: R385.2(P2) U2.P17(USB1_ID) U30.3(ID)
USB1_OVRCURN: R410.2(P2) R412.2(P2) U29.5(O\C\)
USB5V_FB: R520.1(P1) R521.2(P2) U24.E3(FB)
VADDL_PHY: C198.1 C199.1 C200.1 C201.1 FB16.1 U25.8(AVDDL#8) U25.13(AVDDL#13) U25.19(AVDDL#19) U25.44(AVDDL#44)
VAUX1: J19.16 R474.2(P2) R502.1(I1)
VAUX2: C203.1 FB2.2 FB6.2 FB8.2 FB20.2 J4.1 J19.17 R68.2(P2) R475.2(P2)
VAUX33: J19.18 R463.1(P1) R504.1(I1)
VBCKUPBAT: BT1.1(POS) TP26.1 U4.27(VBACKUP)
VCOM_BAT: C161.1 C171.1 C172.1 J11.5 J11.7 R359.2 U17.4(OUT)
VCOM_BATEN: R358.1(P1) U17.1(EN)
VCOM_BATFB: C171.2 R359.1 R360.2(P2) U17.5(FB)
VDAC: J19.14 R471.2(P2) R498.2(I2)
VDIG1: FB1.2 FB3.2 FB7.2 FB21.2 J19.11 R464.1(P1) R472.2(P2)
VDIG2: J19.12 R476.1(P1) R497.1(I1) R499.1(I1) R500.1(I1) R503.2(I2) R506.2(I2) R507.1(I1)
VETH_AVDD_3_3: C194.1 C248.1 FB15.2 U25.16(AVDD33)
VETH_LX: L7.2 U25.3(LX)
VETH_VDDIO: C193.1 R388.1(P1) R389.2(P2) R407.1(P1) R408.2(P2) U25.29(VDDIO_REG)
VMMC: FB4.2 FB5.2 J19.13 R477.1(P1)
VPLL: FB9.2 J19.15 R473.2(P2)
VPMIC_VRTC: C97.1 R53.1(P1) R60.2(P2) U4.29(VRTC)
VPWRIN_FUSED: D2.1(CATHODE) F1.2 SW1.1
VPWRIN_JCK: D1.2(ANODE) J1.1
VPWRIN_PREFUSE: D1.1(CATHODE) F1.1
VREFP_ADC: C9.1 C10.1 C11.1 C12.1 R30.2(P2) U2.B9(VREFP)
VRTC: C1.1 C7.1 C91.1 C111.1 J19.3 R53.2(P2) R54.2(P2) R393.2(P2) R505.2(I2) R557.1(P1) U1.1(A) U1.5(VCC) U6.1(2A) U6.2(2B) U6.8(VCC) U33.6(VCCB)
VUSB_VBUS0: C183.1 C262.1 J14.1(VBUS) J36.1 R563.1 U22.6(OUT#6) U22.7(OUT#7) U22.8(OUT#8) U23.6(VBUS)
VUSB_VBUS1: C186.1 C265.1 J18.1(VBUS) J37.1 R558.1(P1) R564.1 U29.6(OUT#6) U29.7(OUT#7) U29.8(OUT#8) U30.6(VBUS)
N17759: C5.1 R7.1(P1) R8.2(P2) Y2.1
N120395: D3.2(ANODE) R50.1(P1)
N124510: J2.4(TDIS) R73.2(P2)
N150689: C3.2 R5.2(P2) Y1.1
N194366: C9.2 C10.2 C13.1 C14.1 R51.1(P1) U2.A9(VREFN)
N16794306: J15.D1 R390.2
N16794816: J15.D4 R392.2
N16958667: R308.2(P2) U10.69(IO_SEL)
N17034041: R114.2(P2) SW3.1
N17034069: R115.2(P2) SW3.2
N17034107: R116.2(P2) SW3.3
N17034117: R117.2(P2) SW3.4
N17034161: R118.2(P2) SW3.5
N17034171: R119.2(P2) SW3.6
N17034215: R120.2(P2) SW3.7
N17034225: R121.2(P2) SW3.8
N17059155: R325.2(P2) U10.36(SPDIF)
N17084504: D8.1(CATHODE) R277.2(P2)
N17084966: R326.2(P2) U10.72(CI2CA)
N17107785: C98.1 U4.18(VREF)
N17298950: C179.1 U18.6(V-)
N17298952: C177.1 U18.2(V+)
N17298960: C176.2 U18.3(C1-)
N17298962: C178.1 U18.4(C2+)
N17298964: C178.2 U18.5(C2-)
N17298974: C176.1 U18.1(C1+)
N17338171: R354.2(P2) U16.4(1A1)
N17338175: R355.2(P2) U16.5(1A2)
N17338916: R356.2(P2) U16.6(2A1)
N17338919: R357.2(P2) U16.7(2A2)
N17339217: R347.2(P2) U14.5(1A2)
N17339337: R348.2(P2) U14.6(2A1)
N17339991: R346.2(P2) U14.4(1A1)
N17340025: R335.2(P2) U13.6(2A1)
N17340083: R336.2(P2) U13.7(2A2)
N17342017: R350.2(P2) U15.4(1A1)
N17342025: R351.2(P2) U15.5(1A2)
N17342093: R352.2(P2) U15.7(2A2)
N17345501: R122.2(P2) SW4.1
N17345515: R123.2(P2) SW4.2
N17345519: R124.2(P2) SW4.3
N17345529: R125.2(P2) SW4.4
N17345551: R126.2(P2) SW4.5
N17345553: R127.2(P2) SW4.6
N17345567: R128.2(P2) SW4.7
N17345577: R129.2(P2) SW4.8
N17563948: Q1.G(GATE) R84.1(P1) R85.1(P1) R86.2(P2) R509.1(P1)
N17563994: D4.2(ANODE) R80.1(P1)
N17563997: D4.1(CATHODE) Q1.D(DRAIN)
N17564510: D5.1(CATHODE) Q2.D(DRAIN)
N17564514: D5.2(ANODE) R81.1(P1)
N17564644: D6.1(CATHODE) Q3.D(DRAIN)
N17564648: D6.2(ANODE) R82.1(P1)
N17564780: D7.1(CATHODE) Q4.D(DRAIN)
N17564784: D7.2(ANODE) R83.1(P1)
N17564892: Q2.G(GATE) R87.1(P1) R88.1(P1) R93.2(P2) R510.1(P1)
N17564904: Q3.G(GATE) R89.1(P1) R90.1(P1) R95.2(P2) R511.1(P1)
N17564916: Q4.G(GATE) R91.1(P1) R92.1(P1) R94.2(P2) R512.1(P1)
N17601395: R349.2(P2) R492.2(P2) U14.7(2A2)
N17618848: C212.2 U25.6(XTLO) Y3.1
N17618850: C204.2 U25.7(XTLI) Y3.2
N17618867: TP47.1 U25.45(SIN)
N17619022: TP49.1 U25.42(SON)
N17619024: TP48.1 U25.43(SOP)
N17619221: R393.1(P1) R405.1(P1) R479.1(P1) U25.40(WOL_INT)
N17619435: R395.2(P2) TP50.1
N17619707: R394.2(P2) U25.41(SD)
N17619739: TP46.1 U25.46(SIP)
N17684279: J8.12 R239.1(P1)
N17684406: R63.1(P1) U4.33(PWRON)
N17710761: R22.2(P2) U2.J3(DDR_VTP)
N17828529: TP2.1 U2.G2(DDR_RESETN)
N18082443: R328.2(P2) U13.4(1A1)
N18136628: R72.1(P1) U7.7(WP)
N18365790: R57.1(P1) U4.39(GPIO_CKSYNC)
N18368859: R69.2(P2) U6.7(2Y)
N19410176: R518.1(P1) U15.6(2A1)
N19410226: R519.1(P1) U13.12(1B2)
N19440113: L9.1 U24.B1(L1#B1) U24.B2(L1#B2)
N19440133: L9.2 U24.D1(L2#D1) U24.D2(L2#D2)
N19440219: C264.1 U24.A3(VINA) U24.B3(VINA1) U24.C4(P\S\) U24.D4(VSEL)
N19490589: TP24.1 U2.A3(RESERVED)
N19558182: R544.1(P1) U32.2(A0)
N19577113: R64.1(P1) U4.26(BOOT0)
N19577116: R60.1(P1) U4.19(BOOT1)
N21001557: R112.2(P2) R156.2(P2) SW5.1 SW5.2
N21001559: R559.1(P1) R560.2(P2) SW5.3 SW5.4
N21339295: Q5.D(DRAIN) R23.2(P2)
N21611030: R1.1(P1) U3.1(A)

Pads without a net: J2 6; J3 4 6 8 10 12 14 16 18 20 22; J4 2 3 4 5 6 9 10 13 14 15 16 17 18 20 22 24 27; J5 5 7 9 40; J10 14; J11 10 12 14 16 17 21 23 25 27 29 31 33 36 38 40 41 43 44 45 46 49 51 53 55 57 59 61 65 67 69 71 73 74 75 78 79 80 81 82 84 85 86 88 90 91 93 94 96 98 99 100; J12 1 4 6 9; J13 25 26; J15 M1 M2; J16 7 9 18 22 24 25 26; J17 5; R566 2; SW1 3; U2 D3; U4 20 21 25 38; U5 4; U6 3; U8 A2 L7; U9 1 2 3 4 5 6 10 11 14 15 20 21 22 23 24 35 38; U12 4; U13 5; U15 11; U19 4 9; U20 3 4 6 9; U21 2; U23 5; U26 1; U30 5; U31 A2 L7; Y1 2 3; Y2 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 185 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 2644 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 18 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 1447.5
  TOP w0.076: v2(95.56,59.04) U31.E7
  TOP w0.102: v1(77.51,78.2) 77.24,77.93 74.37,77.93 74.07,77.63 72.21,77.63 v2(71.71,77.13) 71.71,77.84 71.57,77.98 71.57,78.45 72.06,78.93 76.09,78.93 76.31,79.16 v2(76.75,79.16)
  TOP w0.121: U24.C1 U24.C2 U24.C3 U24.D3 ; v2(154.6,145.96) 154.89,146.25 U24.E4 ; v2(156.25,145.58) 156.39,145.73 U24.B4 ; v2(36.88,59.59) 36.88,62.15 37.15,62.42 40.83,62.42 41.16,62.09 41.16,60.24 40.7,59.78 38.44,59.78 38.31,59.65 38.31,59.53 38.29,59.51 v2(38.29,59.07) ; v2(60.48,114.43) 60.22,114.17 57.13,114.17 56.88,114.42 50.46,114.42 50.28,114.25 49.92,114.25 49.66,114.51 49.66,114.88 50,115.21 v2(50.67,115.21) 56.79,115.21 57.34,114.67 58.79,114.67 v2(59.28,115.16) 82.63,115.16 83.17,115.7 85.38,115.7 85.88,116.19 v2(86.6,116.19) 86.91,115.88 86.91,115.58 86.44,115.11 83.28,115.11 82.84,114.67 60.72,114.67 v2(60.48,114.43) ; 60.96,113.32 61.45,113.81 81.97,113.81 v2(82.31,113.47) 82.7,113.08 85.78,113.08 85.95,113.25 87.34,113.25 87.6,113 87.6,112.63 87.34,112.37 86.37,112.37 86.2,112.2 v2(82.41,112.2) 81.73,112.2 80.63,113.3 61.65,113.3 61.17,112.83 51.81,112.83 51.45,112.47 41.22,112.47 v2(40.58,113.12) 41.06,113.6 46,113.6 46.62,112.98 49.22,112.98 49.58,113.35 v2(50.02,113.35) 50.47,113.35 50.49,113.32 60.96,113.32
  TOP w0.203: D10.2 89.74,100.81 v2(89.72,100.82) ; v3(90.72,32.42) 90.85,32.29 U4.15 ; U4.17 93.39,33.09 v2(93.51,33.22) ; U4.PPAD 88.05,34.64 U4.34 ; U6.4 87.67,22.78 87.43,23.02 C111.2 ; U4.43 87.98,33.49 v3(88.18,33.69) ; D9.2 v2(94.91,96.18)
  TOP w0.254: J10.17 144.16,7.2 144.21,7.15 v2(144.21,6.97) ; U28.2 23.77,111.4 v2(23.91,111.54) ; J10.2 v2(151.66,7.08) ; U28.11 v2(20.24,107.87) ; U32.1 v2(61.86,36.72) ; J11.42 v2(4.61,122.47) ; J10.5 v2(150.16,7.07) ; U6.5 90.7,22.78 v2(90.46,23.02) 90.72,23.28 U6.6 ; U24.C1 v2(155.99,148.12) ; v2(4.36,115.23) 4.74,114.85 J11.18 ; U21.4 65.73,144.06 v2(66.25,144.59) ; J10.11 v2(147.16,7.03) ; U19.5 v2(60.11,144.06) ; U32.7 v2(65.77,34.65) ; J10.8 v2(148.66,7.04) ; v2(4.36,116.12) 6.07,116.12
  TOP w0.305: v1(84.2,82.6) U2.J7 ; U15.8 24.94,139.73 v2(24.68,139.99) ; J11.2 4.74,109.77 v2(4.36,109.38) ; U15.15 21.53,135.83 v2(21.88,136.18) 21.59,136.48 U15.14 ; U13.8 24.94,120.68 v2(24.68,120.94) ; U13.9 21.62,120.68 v2(21.88,120.94) ; U13.14 21.59,117.43 v2(21.88,117.13) 21.53,116.78 U13.15 ; U16.14 21.59,130.13 v2(21.88,129.83) 21.53,129.48 U16.15 ; v2(7.66,111.42) 7.28,111.04 6.07,111.04 ; U10.70 144.13,29.2 v2(144.31,29.37) ; v1(84.2,81.8) U2.J6 ; v2(137.71,29.37) 137.63,29.3 U10.57 ; v2(137.71,34.69) U10.43 ; U10.63 v2(140.63,29.37) ; U9.36 149.26,117.39 v2(149.52,117.64) ; v2(149.52,98.08) 149.25,97.82 U9.13 ; U10.55 v2(136.06,28.49) ; v2(21.88,139.99) 21.62,139.73 U15.9 ; U16.3 27.07,130.13 v2(27.42,129.78) ; U9.48 v2(143.26,117.48) ; J11.60 7.53,128.18 v2(7.66,128.05) ; U2.A18 77.89,92.11 v1(77.89,92.24) ; v2(21.88,127.29) 21.62,127.03 U14.9 ; v1(81.8,83.4) U2.F8 ; v2(24.68,133.64) 24.94,133.38 U16.8 ; v2(21.88,133.64) 21.62,133.38 U16.9 ; v2(154.98,117.51) 154.76,117.3 U9.25 ; U14.8 24.94,127.03 v2(24.68,127.29) ; U14.14 21.59,123.78 v2(21.88,123.48) 21.53,123.13 U14.15 ; U2.V1 v1(92.5,78.2) ; U2.A1 v1(77.51,78.2)
  TOP w0.381: v2(99.56,61.44) U31.A3 ; v1(85.8,84.2) U2.K9 ; v2(96.36,61.44) U31.E3 ; R426.1 v2(38.3,51.73) ; J13.18 58.03,147.41 v2(58.33,147.1) 58.71,147.1 58.88,147.27 J13.6 ; R419.1 v2(38.3,53) ; C6.2 v2(62.98,105.27) U33.2 ; v1(88.2,86.6) U2.N11 ; v2(131.65,27.72) 131.71,27.72 R569.1 ; U2.M8 v1(87.4,84.2) U2.M9 ; U14.3 27.3,123.78 v2(27.47,123.61) ; U3.3 62.09,99.5 60.64,99.5 v2(60.24,99.1) ; U30.4 v2(149.07,161.89) 149.2,162.03 R385.1 ; v2(71.71,77.13) 71.09,77.13 R48.1 ; U13.2 24.96,116.78 v2(24.8,116.62) ; v1(88.2,85.8) U2.N10 ; J11.77 v2(12.48,137.07) ; U2.G9 v1(83.4,84.2) U2.H9 ; R414.1 v2(38.3,56.81) ; v2(73.34,59.04) U8.E7 ; v2(92.36,63.84) U31.J1 ; C111.2 v2(87.03,22.26) ; C137.2 v2(141.64,88.05) ; FB14.1 v2(135.73,163.53) ; v2(15.91,110.27) 15.79,110.4 J11.3 ; U26.3 23.39,60.86 22.76,60.86 v2(22.39,60.49) ; U20.5 v2(71.92,151.35) ; 14.07,121.2 12.74,121.2 v2(12.36,120.81) 12.61,120.56 J11.35 ; U11.14 143.46,12.1 v2(142.15,12.1) ; 29.41,85.38 v2(27.47,85.38) ; 52.36,65.7 52.36,66.46 v2(52.11,66.71) ; v2(70.14,63.84) U8.J1 ; 148.37,163.11 148.88,163.11 v2(149.07,162.91) ; R413.1 v2(38.3,54.27) ; 97.07,87.79 v2(97.7,88.43) ; J11.19 v2(12.23,115.48) ; C264.2 v2(155.61,142.91) ; v2(155.99,149.64) v2(155.99,148.88) v2(155.99,148.12) ; C175.2 v2(111.29,25.51) ; v1(82.6,83.4) U2.G8 ; v1(87.4,81.8) U2.M6 ; v2(69.34,56.64) U8.K9 ; v1(88.2,82.6) U2.N7 ; U1.3 54.81,99.92 v2(54.47,99.58) ; v1(83.4,83.4) U2.H8 ; J2.12 v2(31.28,90.46) ; 29.41,87.92 v2(31.41,87.92) ; J11.95 15.28,142.79 v2(15.66,143.17) 15.4,143.42 J11.97 ; R411.1 v2(38.3,55.54) ; R422.1 v2(38.3,58.08) ; v1(84.2,85.8) U2.J10 ; U2.N14 v1(87.4,89) U2.M14 ; v1(84.2,83.4) U2.J8 ; C15.2 v2(27.85,107.35) ; v2(74.94,57.44) U8.D8 ; v2(148.5,20.74) 148.56,20.67 148.56,20.4 148.63,20.33 U12.2 ; C187.2 159.68,145.33 v2(159.42,145.07) ; C263.2 158.39,145.49 158.15,145.25 v2(158.15,144.44) ; v2(12.36,122.08) 12.61,121.83 J11.39 ; J2.10 v2(27.6,91.73) ; v2(74.94,62.24) U8.D2 ; v1(85.8,82.6) U2.K7 ; J11.87 v2(12.48,140.25) ; v1(82.6,87.4) U2.G12 ; v2(12.23,112.56) 12.48,112.31 J11.9 ; v1(87.4,87.4) U2.M12 ; J13.28 v2(39.1,163.69) ; v2(76.54,57.44) U8.B8 ; v2(91.56,56.64) U31.K9 ; U2.L13 v1(86.6,87.4) U2.L12 ; v2(97.16,57.44) U31.D8 ; v2(133.9,163.84) 133.13,163.84 C183.2 133.01,163.68 133.07,163.62 133.07,163.15 132.87,162.95 U23.4 133.51,162.76 133.57,162.7 R381.1 ; U11.6 v2(136.11,15.35) ; J2.8 v2(31.28,93) ; v2(77.33,58.24) U8.A7 ; 14.07,138.98 v2(12.48,138.98) ; v1(87.4,85.8) U2.M10 ; v2(74.14,61.44) U8.E3 ; U33.5 59.07,105.27 58.99,105.35 v2(58.05,105.35) 57.67,105.35 57.39,105.07 C7.2 ; v2(77.33,61.44) U8.A3 ; v2(71.63,48.61) 72.17,48.07 C355.2 ; v2(98.76,62.24) U31.B2 ; v1(84.2,84.2) U2.J9 ; U2.G11 v1(83.4,85.8) U2.H10 ; U2.H7 v1(84.2,82.6) ; J11.92 v2(4.36,141.52) ; v1(85.8,85.8) U2.K10 ; J11.64 4.99,132.63 v2(4.61,132.24) ; v2(99.69,58.64) U31.A7 ; v1(86.6,85.8) U2.L10 ; v1(83.4,87.4) U2.H12 ; U5.2 v2(84.11,22.52) ; J11.63 v2(12.36,132.63) ; v1(86.6,86.6) U2.L11 ; U2.H6 v1(84.2,81.8) ; v2(49.31,85) C28.2 ; v2(76.54,62.24) U8.B2 ; U11.19 v2(142.09,15.35) ; v1(85.8,86.6) U2.K11 ; v2(97.16,62.24) U31.D2 ; v2(98.76,57.44) U31.B8 ; J13.27 v2(67.4,163.92) ; U2.J11 v1(84.2,86.6) ; v1(87.4,82.6) U2.M7 ; J11.47 v2(12.36,124.37) ; J14.5 v2(129.42,164.8)
  TOP w0.508: C8.2 66.15,101.76 v2(65.4,101.76) ; Q4.S 7.78,74.65 v2(7.78,74.34) ; C234.2 92.75,17.71 v2(92.75,16.61) ; C133.2 v2(136.82,128.37) ; 27.47,57.19 v2(27.47,57.95) ; v2(26.58,54.52) 26.96,54.14 C192.2 ; C272.1 v2(21.12,10.32) ; v2(79.92,22.77) 79.92,21.25 79.16,20.48 D2.2 78.4,21.12 v2(78.4,22.9) ; v2(31.41,62.9) 31.4,62.9 31.4,62.02 C197.2 ; 11.59,84.11 v2(12.15,83.58) ; C114.2 v2(92.62,22.26) ; J13.21 52.23,147.28 51.98,147.04 v2(51.85,147.04) 51.8,147.04 51.38,147.46 J13.3 ; C103.2 v2(88.18,25.82) ; v2(95.03,13.88) 95.03,12.61 95.41,12.23 C84.2 ; v2(7.78,78.78) 7.78,79.09 Q3.S ; C88.2 v2(92.63,19.34) ; C259.2 100.6,87.41 v2(101.76,87.41) ; C74.2 v2(20.87,113.58) ; D3.1 v2(83.62,15.93) ; v2(129.82,87.2) 129.78,87.16 129.58,87.16 C139.2 ; v2(7.4,87.67) 7.4,88.24 Q1.S ; BT1.2 v2(106.32,43.82) ; U2.V18 v1(91.8,92.37) ; SW2.2 v2(6.8,63.1) ; v2(156.88,17.31) 156.88,18.09 C244.2 157.77,17.96 v2(157.77,17.31) ; C85.2 v2(92.6,20.36) ; v2(30.39,64.43) 30.39,63.78 C256.2 29.5,63.65 v2(29.5,64.43) ; R274.1 v2(141.77,75.98) ; C107.2 v2(87.03,25.82) ; FB19.1 v2(156.18,163.55) ; Q2.S 7.78,83.54 v2(7.78,83.23) ; C60.2 68.74,87.42 v2(68.5,87.67) ; C84.2 97.19,12.23 97.7,12.74 v2(97.7,13.75) ; C84.2 v2(96.31,13.75) ; C86.2 v2(92.6,21.37) ; 110.53,136.82 v2(111.26,136.82) ; R326.1 v2(163.11,19.6) ; C61.2 v2(118.35,136.94) ; C255.2 v2(52.4,143.04) ; C222.2 v2(69,33.44) ; C131.2 v2(148.58,119.8) ; U18.15 113.32,21.75 v2(113.58,21.5) ; U7.4 v2(142.21,63.73) ; R94.1 v2(12.36,75.22) ; 27.98,110.53 v2(28.74,110.53) ; U7.3 v2(140.94,66.9) ; C113.2 v2(82.21,21.25) ; C172.2 v2(18.69,101.02) ; C375.2 v2(69.63,34.2) ; C159.2 v2(150.53,19.72) ; C206.2 38.77,47.03 v2(39.03,46.77) ; R95.1 v2(12.48,79.67) ; U22.1 v2(133.51,146.71) ; C112.2 v2(86.02,23.28) ; C212.1 v2(21.12,57.31) ; C179.2 v2(103.16,16.67) ; C374.2 v2(63.92,32.3) ; C130.2 v2(150.86,119.8) ; C117.2 v2(12.28,60.36) ; C213.2 v2(23.15,63.79) ; U7.1 v2(138.4,66.84) ; C271.1 v2(44.61,11.21) ; C205.2 v2(37.5,46.65) ; U17.3 v2(10.32,101.64) ; R308.1 v2(160.82,19.6) ; C214.2 v2(107.86,155) ; C128.2 v2(149.52,95.29) ; C204.1 v2(21.12,54.77) ; U7.2 v2(139.67,63.73) ; R86.1 v2(12.23,88.56) ; R360.1 v2(18.2,104.05) ; C268.2 v2(151.5,14.15) ; 133.64,127.67 v2(133.64,126.94) ; 106.72,24.42 v2(105.88,24.42) ; SW2.1 v2(6.8,61.18) ; U17.6 v2(6.64,101.64) ; C173.2 v2(14.64,101.51)
  TOP w0.635: C185.2 v2(164.38,155.61) ; v2(106.72,66.46) 106.19,66.46 C233.2 ; v2(142.95,157.49) C265.2 v2(144.06,156.31) ; U29.1 v2(140.8,144.83) ; C266.2 v2(70.76,71.01) ; C232.2 63.17,69.9 v2(62.65,69.38) ; C182.2 v2(124.37,150.47) ; 69.38,73.7 v2(70.4,73.7)
  TOP w0.762: v2(137.51,156.25) C262.2 v2(138.62,157.68)
  LY2_GND w0.483: 135.11,75.09 J7.19 135.93,74.48 ; 137.2,74.48 J7.20 138.01,75.09 ; 131.48,74.48 J8.19 130.67,75.09 ; 133.56,75.09 J8.20 132.75,74.48
  LY2_GND w0.502: 133.26,90.44 J3.28 ; J3.28 132.35,91.35 ; J3.28 134.17,91.35 ; J3.28 133.26,92.26 ; J12.5 122.38,10.41 ; J12.5 120.47,10.41 ; J12.5 121.42,11.37 ; J12.5 121.42,9.46 ; J12.10 131.08,8.99 ; J12.10 128.38,11.68 ; J12.10 125.69,8.99 ; J12.10 128.38,6.3 ; 124.73,116.75 J4.8 ; J4.8 125.64,115.84 ; J4.8 126.55,116.75 ; J4.8 125.64,117.66 ; 50.71,136.16 J5.37 ; J5.37 50.71,137.98 ; J5.37 51.62,137.07 ; J5.37 49.8,137.07 ; 7.12,93.51 TP27.1 ; TP27.1 9.21,93.51 ; TP27.1 8.17,94.55 ; TP27.1 8.17,92.47 ; 140.16,6.38 J10.MTG1 ; J10.MTG1 140.16,8.46 ; J10.MTG1 141.2,7.42 ; J10.MTG1 139.12,7.42 ; 123.74,15.82 J19.19 ; J19.19 124.65,16.74 ; J19.19 122.82,16.74 ; J19.19 123.74,17.65 ; 74.69,5.12 SW1.M1 ; SW1.M1 75.6,6.03 ; SW1.M1 75.6,4.2 ; SW1.M1 76.52,5.12 ; J19.10 123.74,40.51 ; J19.10 124.65,39.6 ; J19.10 123.74,38.68 ; J19.10 122.82,39.6 ; 128.18,115.84 J4.7 ; J4.7 129.09,116.75 ; J4.7 128.18,117.66 ; J4.7 127.27,116.75 ; 86.27,138.7 J5.10 ; J5.10 85.36,139.61 ; J5.10 87.18,139.61 ; J5.10 86.27,140.52 ; 85,166.51 TP30.1 ; TP30.1 86.04,167.55 ; TP30.1 83.96,167.55 ; J1.2 62.58,12.15 ; J1.2 60.59,14.15 ; J1.2 58.6,12.15 ; J1.2 60.59,10.16 ; 25.93,1.69 J15.D2 ; J15.D2 27.63,1.69 ; J15.D2 26.78,2.54 ; 166.51,91.35 TP28.1 ; TP28.1 167.55,92.39 ; TP28.1 167.55,90.31 ; J5.1 96.43,137.98 ; J5.1 95.52,137.07 ; J5.1 97.34,137.07 ; J5.1 96.43,136.16 ; J6.3 85.91,125.64 ; J6.3 85,124.73 ; J6.3 84.09,125.64 ; J6.3 85,126.55 ; J19.20 124.65,14.2 ; J19.20 122.82,14.2 ; J19.20 123.74,15.11 ; J19.20 123.74,13.28 ; J16.15 96.07,159.93 ; J16.15 94.25,159.93 ; J16.15 95.16,159.02 ; J16.15 95.16,160.84 ; 79.01,162.47 J16.28 ; J16.28 79.92,161.56 ; J16.28 80.83,162.47 ; J16.28 79.92,163.38 ; 122.82,52.3 J19.5 ; J19.5 123.74,51.38 ; J19.5 124.65,52.3 ; J19.5 123.74,53.21 ; 153.62,7.42 J10.MTG2 ; J10.MTG2 154.66,8.46 ; J10.MTG2 154.66,6.38 ; J10.MTG2 155.7,7.42 ; 68.49,42.3 J17.3 ; J17.3 68.49,44.39 ; J17.3 69.53,43.34 ; J17.3 67.45,43.34 ; 72.3,127.27 J6.14 ; J6.14 71.39,128.18 ; J6.14 72.3,129.09 ; J6.14 73.21,128.18 ; J12.11 103.39,11.68 ; J12.11 103.39,6.3 ; J12.11 100.7,8.99 ; J12.11 106.08,8.99 ; 141.46,165.01 J18.4 ; J18.4 142.45,166 ; J18.4 143.44,165.01 ; J18.4 142.45,164.02 ; J15.1 28.71,15.15 ; J15.1 27.85,14.29 ; J15.1 26.99,15.15 ; J15.1 27.85,16.01 ; 73.57,138.7 J5.20 ; J5.20 74.48,139.61 ; J5.20 72.66,139.61 ; J5.20 73.57,140.52 ; J5.11 84.64,137.07 ; J5.11 82.82,137.07 ; J5.11 83.73,136.16 ; J5.11 83.73,137.98 ; J15.D3 41.2,3.72 ; J15.D3 40.35,2.87 ; J15.D3 39.5,3.72 ; 64.68,127.27 J6.20 ; J6.20 65.59,128.18 ; J6.20 64.68,129.09 ; J6.20 63.77,128.18 ; J3.27 135.8,92.26 ; J3.27 134.89,91.35 ; J3.27 135.8,90.44 ; J3.27 136.71,91.35 ; J10.MTG3 140.6,2.52 ; J10.MTG3 139.56,3.56 ; J10.MTG3 138.52,2.52 ; 56.15,125.64 J6.25 ; J6.25 57.97,125.64 ; J6.25 57.06,126.55 ; J6.25 57.06,124.73 ; SW1.M2 81.6,5.12 ; SW1.M2 79.77,5.12 ; SW1.M2 80.68,6.03 ; SW1.M2 80.68,4.2 ; 79.01,159.93 J16.27 ; J16.27 79.92,160.84 ; J16.27 79.92,159.02 ; J16.27 80.83,159.93 ; 91.86,1.66 TP29.1 ; TP29.1 90.82,2.7 ; TP29.1 92.9,2.7 ; TP29.1 91.86,3.75 ; 55.79,6.91 J1.3 ; J1.3 57.78,8.9 ; J1.3 55.79,10.9 ; J1.3 53.8,8.9 ; J10.MTG4 156.3,2.52 ; J10.MTG4 155.26,3.56 ; J10.MTG4 154.22,2.52 ; 60.87,138.7 J5.30 ; J5.30 59.96,139.61 ; J5.30 61.78,139.61 ; J5.30 60.87,140.52
  LY2_GND w0.635: 49.82,58.58 50.96,58.58
  LY4 w0.133: 87.92,39.64 87.92,38.52 v2(88.23,38.21) 88.51,38.21 88.94,38.65 88.94,44.61 81.85,51.7 81.85,59.21 83.35,60.71 83.35,65.6 80.66,68.29 80.11,68.29 73.8,74.61 73.8,77.38 72.27,78.9 71.77,78.9 71.51,78.65 71.51,77.32 v2(71.71,77.13) 72.55,77.13 72.93,76.75 72.93,74.39 80,67.32 80.55,67.32 82.52,65.35 82.52,60.96 81.06,59.51 81.06,59.5 80.97,59.4 80.97,51.41 88.04,44.33 88.04,39.76 87.92,39.64
  LY5_GND w0.483: 135.93,74.48 J7.19 135.11,75.09 ; 138.01,75.09 J7.20 137.2,74.48 ; 131.48,74.48 J8.19 130.67,75.09 ; 132.75,74.48 J8.20 133.56,75.09
  LY5_GND w0.502: J17.3 69.53,43.34 ; J17.3 67.45,43.34 ; J17.3 68.49,42.3 ; J17.3 68.49,44.39 ; J6.3 85,126.55 ; J6.3 84.09,125.64 ; J6.3 85.91,125.64 ; J6.3 85,124.73 ; 79.77,5.12 SW1.M2 ; SW1.M2 81.6,5.12 ; SW1.M2 80.68,6.03 ; SW1.M2 80.68,4.2 ; 153.62,7.42 J10.MTG2 ; J10.MTG2 154.66,6.38 ; J10.MTG2 155.7,7.42 ; J10.MTG2 154.66,8.46 ; J6.14 73.21,128.18 ; J6.14 72.3,129.09 ; J6.14 72.3,127.27 ; J6.14 71.39,128.18 ; J12.11 106.08,8.99 ; J12.11 103.39,6.3 ; J12.11 100.7,8.99 ; J12.11 103.39,11.68 ; J16.27 79.92,160.84 ; J16.27 80.83,159.93 ; J16.27 79.92,159.02 ; J16.27 79.01,159.93 ; 122.82,39.6 J19.10 ; J19.10 123.74,38.68 ; J19.10 123.74,40.51 ; J19.10 124.65,39.6 ; J15.D2 27.63,1.69 ; J15.D2 26.78,2.54 ; J15.D2 25.93,1.69 ; J16.15 95.16,160.84 ; J16.15 95.16,159.02 ; J16.15 94.25,159.93 ; J16.15 96.07,159.93 ; 50.71,136.16 J5.37 ; J5.37 49.8,137.07 ; J5.37 51.62,137.07 ; J5.37 50.71,137.98 ; 140.16,6.38 J10.MTG1 ; J10.MTG1 139.12,7.42 ; J10.MTG1 140.16,8.46 ; J10.MTG1 141.2,7.42 ; TP27.1 8.17,94.55 ; TP27.1 7.12,93.51 ; TP27.1 9.21,93.51 ; TP27.1 8.17,92.47 ; 82.82,137.07 J5.11 ; J5.11 83.73,136.16 ; J5.11 84.64,137.07 ; J5.11 83.73,137.98 ; 138.52,2.52 J10.MTG3 ; J10.MTG3 140.6,2.52 ; J10.MTG3 139.56,3.56 ; 96.43,136.16 J5.1 ; J5.1 96.43,137.98 ; J5.1 97.34,137.07 ; J5.1 95.52,137.07 ; J16.28 80.83,162.47 ; J16.28 79.01,162.47 ; J16.28 79.92,161.56 ; J16.28 79.92,163.38 ; J6.25 57.97,125.64 ; J6.25 56.15,125.64 ; J6.25 57.06,126.55 ; J6.25 57.06,124.73 ; J12.5 122.38,10.41 ; J12.5 121.42,11.37 ; J12.5 121.42,9.46 ; J12.5 120.47,10.41 ; 86.27,138.7 J5.10 ; J5.10 85.36,139.61 ; J5.10 87.18,139.61 ; J5.10 86.27,140.52 ; 55.79,6.91 J1.3 ; J1.3 53.8,8.9 ; J1.3 57.78,8.9 ; J1.3 55.79,10.9 ; J19.20 124.65,14.2 ; J19.20 122.82,14.2 ; J19.20 123.74,15.11 ; J19.20 123.74,13.28 ; J4.8 125.64,117.66 ; J4.8 125.64,115.84 ; J4.8 126.55,116.75 ; J4.8 124.73,116.75 ; 40.35,2.87 J15.D3 ; J15.D3 41.2,3.72 ; J15.D3 39.5,3.72 ; J19.5 124.65,52.3 ; J19.5 122.82,52.3 ; J19.5 123.74,53.21 ; J19.5 123.74,51.38 ; 167.55,90.31 TP28.1 ; TP28.1 166.51,91.35 ; TP28.1 167.55,92.39 ; J19.19 124.65,16.74 ; J19.19 122.82,16.74 ; J19.19 123.74,17.65 ; J19.19 123.74,15.82 ; SW1.M1 75.6,6.03 ; SW1.M1 75.6,4.2 ; SW1.M1 76.52,5.12 ; SW1.M1 74.69,5.12 ; 59.96,139.61 J5.30 ; J5.30 60.87,138.7 ; J5.30 60.87,140.52 ; J5.30 61.78,139.61 ; J15.1 27.85,16.01 ; J15.1 28.71,15.15 ; J15.1 26.99,15.15 ; J15.1 27.85,14.29 ; 73.57,138.7 J5.20 ; J5.20 72.66,139.61 ; J5.20 74.48,139.61 ; J5.20 73.57,140.52 ; J3.28 133.26,92.26 ; J3.28 134.17,91.35 ; J3.28 132.35,91.35 ; J3.28 133.26,90.44 ; 154.22,2.52 J10.MTG4 ; J10.MTG4 156.3,2.52 ; J10.MTG4 155.26,3.56 ; J12.10 128.38,11.68 ; J12.10 131.08,8.99 ; J12.10 125.69,8.99 ; J12.10 128.38,6.3 ; 63.77,128.18 J6.20 ; J6.20 64.68,129.09 ; J6.20 65.59,128.18 ; J6.20 64.68,127.27 ; J18.4 142.45,166 ; J18.4 143.44,165.01 ; J18.4 142.45,164.02 ; J18.4 141.46,165.01 ; J1.2 62.58,12.15 ; J1.2 60.59,14.15 ; J1.2 58.6,12.15 ; J1.2 60.59,10.16 ; 128.18,115.84 J4.7 ; J4.7 128.18,117.66 ; J4.7 129.09,116.75 ; J4.7 127.27,116.75 ; 91.86,1.66 TP29.1 ; TP29.1 90.82,2.7 ; TP29.1 92.9,2.7 ; TP29.1 91.86,3.75 ; 135.8,90.44 J3.27 ; J3.27 134.89,91.35 ; J3.27 136.71,91.35 ; J3.27 135.8,92.26 ; 85,166.51 TP30.1 ; TP30.1 86.04,167.55 ; TP30.1 83.96,167.55
  BOTTOM w0.121: 37.09,59.3 36.83,59.04 36.83,58.59 37.1,58.33 37.55,58.33 v2(38.29,59.07) 38.49,59.27 38.49,59.73 38.78,60.02 38.78,60.22 39.22,60.67 39.22,63.52 34.23,68.52 v2(34.23,68.97) 34.23,81.03 37.32,84.13 v2(37.32,84.9) 37.32,85.46 37.97,86.11 37.97,98.55 v2(39.25,99.83) 40.18,100.76 40.18,110.67 41.85,112.34 41.85,113.39 41.62,113.63 41.08,113.63 v2(40.58,113.12) 40.58,112.86 40.53,112.82 40.53,112.5 39.89,111.86 39.89,111.33 39.64,111.08 39.64,106.97 39.33,106.66 v2(39.33,106.44) 39.33,106 39.64,105.69 39.64,101.61 v2(38.09,100.06) 37.45,99.43 37.45,86.85 v2(37.06,86.46) 36.59,85.99 36.59,84.47 33.46,81.34 v2(33.46,76.77) 33.46,68.11 v2(35.88,65.7) 36.46,65.11 36.79,65.11 37.28,64.63 38.73,63.18 38.73,60.87 38.28,60.43 38.28,60.23 37.36,59.3 37.09,59.3 ; 37.09,59.3 37.09,59.38 v2(36.88,59.59) ; 43.26,108.45 44,109.2 44,110.91 45.97,112.88 47.89,112.88 48.44,112.88 49.66,114.1 49.66,114.88 50.11,115.33 50.56,115.33 v2(50.67,115.21) 50.76,115.12 50.76,114.08 v2(50.02,113.35) 49.06,112.38 47.89,112.38 43.28,107.77 43.28,99.41 41.9,98.03 v2(41.9,96.02) 41.9,95.33 41.02,94.45 41.02,94.17 41.02,84.84 41.02,84.72 40.96,84.65 v2(40.96,84.21) 40.96,83.45 37.55,80.05 37.55,69.79 42.96,64.38 v2(42.96,62.85) 42.96,57.85 v2(42.56,57.44) 42.24,57.75 42.12,57.75 42.09,57.78 42.07,57.78 41.51,58.34 41.51,59.13 41.87,59.5 v2(41.87,64.3) 41.87,64.55 37.06,69.37 37.06,80.25 39.95,83.15 v2(39.95,84.45) 40.52,85.03 40.52,85.05 40.52,94.93 40.97,95.37 v2(40.97,96.62) 40.97,97.79 42.79,99.61 42.79,107.98 43.26,108.45 ; 43.26,108.45 v2(43.01,108.7)
  BOTTOM w0.254: v2(74.19,123.16) 74.21,123.16 74.52,122.85 C148.2 ; v2(77.33,61.44) 76.62,60.72 C221.2
  BOTTOM w0.305: v2(72.81,47.66) 72.81,47.65 72.68,47.53 U27.2 ; U27.7 65.9,46.53 65.66,46.77 65.57,46.77 C215.2 v2(64.43,46.9) ; 49.82,58.58 50.08,58.58 50.71,59.22 v2(50.78,59.22) ; v2(95.54,79.41) 94.84,79.41 C29.2 ; C125.2 v2(71.03,68.17) ; U27.1 v2(71.63,48.61)
  BOTTOM w0.381: C189.2 v2(96.56,54.9) ; C90.2 88.57,85.42 88.57,85.43 v1(88.2,85.8) ; v2(54.47,99.58) 53.96,99.58 C1.2 ; v2(25.13,105.65) 24.68,106.11 C87.2 ; 71.92,82.71 C30.2 ; C27.2 81.89,88.11 v1(82.6,87.4) 82.6,86.7 C41.2 ; C19.2 83.98,85.58 v1(84.2,85.8) ; C42.2 83.41,87.41 v1(83.4,87.4) ; v2(96.24,72.11) 95.99,71.86 C80.2 ; C79.2 84.85,81.8 v1(84.2,81.8) ; C156.2 98.84,60.72 v2(99.56,61.44) ; v2(97.96,72.18) 98.03,72.11 C82.2 ; C126.2 v2(72.11,54.96) ; C36.2 87.03,84.57 v1(87.4,84.2) ; 95.29,64.68 v2(94.4,64.68) ; 143.04,11.85 142.4,11.85 v2(142.15,12.1) ; C66.2 66.14,60.4 65.89,60.65 65.88,60.65 v2(65.8,60.74) ; C98.2 93.54,33.18 v2(93.51,33.22) ; C216.2 v2(98.46,65.44) ; 74.97,86.27 74.9,86.33 v2(74.3,86.33) ; C184.2 148.12,148.22 v2(148.88,148.98) ; v1(77.89,92.24) 77.89,91.73 78.02,91.6 C47.2 ; v1(87.4,82.6) 87.4,83.3 C31.2 ; C71.2 74.5,87.71 v2(73.57,87.71) ; C76.2 83.41,83.39 v1(83.4,83.4) ; v1(87.4,81.8) 87.25,81.95 C78.2 ; C217.2 v2(75.41,64.68) ; v2(92.36,63.84) 91.86,64.34 C188.2 ; 143.04,18.33 142.4,18.33 v2(142.15,18.58) ; C152.2 v2(144.18,36.74) ; C89.2 101.76,113.7 v2(102.15,114.08) ; C141.2 64.93,122.59 v2(65.32,122.97) ; v1(84.2,90.6) 85,89.8 C83.2 ; v2(106.72,66.46) 106.46,66.2 C64.2 ; C260.2 24.17,85.25 v2(23.41,84.49) ; v2(69.34,56.64) 69.89,56.08 C220.2 ; v1(84.2,82.6) 84.76,82.6 C24.2 ; C77.2 81.76,83.36 v1(81.8,83.4) 81.8,84.09 C53.2 ; C155.2 v2(78.78,55.79) ; C219.2 73.06,64.49 v2(72.55,63.98) ; C205.2 v2(37.5,46.65) ; C35.2 85.13,84.62 85.55,84.2 v1(85.8,84.2) ; v2(99.69,58.64) 99.24,59.08 99.24,59.2 C195.2 ; C34.2 84.72,86.08 v1(84.2,86.6) ; C206.2 38.77,47.03 v2(39.03,46.77) ; v1(87.4,89) 88.06,89 C94.2 ; C174.2 92.11,56.08 v2(91.56,56.64) ; R22.1 v2(83.1,73.95) ; R304.1 v2(141.52,10.45) ; v2(69.32,65.44) 69.63,65.12 C218.2 ; C266.2 v2(70.76,71.01) ; C162.2 v2(3.09,109.38) ; R541.1 v2(85,77.44) ; C181.2 v2(100.75,54.96)
  BOTTOM w0.508: C147.2 135.8,28.75 v2(136.06,28.49) ; C48.2 91.67,92.23 v1(91.8,92.37) ; C354.2 58.33,44.23 v2(58.2,44.36) ; C144.2 v2(141.64,36.74) ; C143.2 v2(144.94,32.04) ; R122.1 R123.1 v2(157.19,89.19) ; C102.2 v2(97.95,39.03) ; C163.2 25.02,116.41 v2(24.8,116.62) ; v2(157.19,66.59) R115.1 R114.1 ; v2(21.88,117.13) 21.63,117.39 C164.2 ; C129.2 v2(149.52,117.64) ; C242.2 150.8,18.6 151.29,19.09 v2(151.29,19.72) ; v2(157.77,17.31) 157.77,17.93 157.25,18.58 156.88,18.09 v2(156.88,17.31) ; C180.2 51.85,147.23 v2(51.85,147.04) ; C145.2 137.43,34.96 v2(137.71,34.69) ; R4.1 61.15,99.38 60.51,99.38 v2(60.24,99.1) ; v2(99.99,36.99) 98.34,36.99 97.95,36.61 C101.2 ; C136.2 v2(134.53,84.62) ; R118.1 R119.1 v2(157.19,56.43) ; C110.2 81.32,29.25 80.81,28.74 v2(80.68,28.74) ; v2(157.19,78.96) 157.12,79.03 R127.1 R126.1 ; C241.2 v2(100.73,33.68) ; C150.2 v2(137.71,33.69) ; C273.2 v2(105.56,94.51) ; C251.2 95.03,37.97 95.03,38.14 v2(95.92,39.03) ; FB10.2 72.36,82.14 71.92,82.59 ; v2(27.47,96.81) R79.1 R73.1 ; v2(157.19,73.9) 157.14,73.95 R129.1 R128.1 ; v2(163.11,19.6) 162.87,19.36 C243.2 ; C169.2 27.15,130.05 v2(27.42,129.78) ; v2(81.75,39.89) 84.03,39.89 C238.2 ; C161.2 15.66,110.53 v2(15.91,110.27) ; v2(21.88,123.48) 21.63,123.74 C166.2 ; 71.92,82.59 71.92,82.71 ; 71.92,82.59 v2(71.92,82.58) ; C146.2 v2(137.71,32.55) ; R292.1 137.83,29.25 v2(137.71,29.37) ; v3(90.72,34.96) 90.84,35.09 R64.2 ; C261.2 v2(113.59,45.01) ; C154.2 140.75,29.49 v2(140.63,29.37) ; 93.26,82.02 93.26,81.43 93.18,81.36 v2(93.18,81.35) ; v2(27.47,123.61) 27.43,123.57 C165.2 ; v2(80.68,30.26) 82.21,30.26 C109.2 82.59,30.9 82.59,34.33 ; C239.2 78.41,32.18 v2(78.02,31.79) ; 27.47,57.19 v2(27.47,57.95) ; C153.2 v2(158.53,19.09) ; v2(98.22,89.22) 98.21,89.22 C93.2 ; C127.2 v2(149.52,98.08) ; C118.2 v2(7.91,43.34) R112.1 ; C32.2 v2(105.7,82.59) ; C116.2 138.91,67.35 v2(138.4,66.84) ; R120.1 R121.1 v2(157.19,51.35) ; v2(80.8,26.93) 81.3,26.93 C236.2 ; v2(21.88,136.18) 21.63,136.44 C168.2 ; v2(21.88,129.83) 21.63,130.09 C170.2 ; C69.2 v2(50.08,96.94) ; v2(129.82,87.2) 130.26,87.65 130.83,87.65 130.85,87.67 C138.2 ; C135.2 v2(48.17,133.39) ; C245.2 112.59,21.3 113.37,21.3 v2(113.58,21.5) ; C134.2 v2(71.03,122.85) ; v2(94.33,89.89) 94.33,89.88 93.9,89.45 C50.2 ; v2(157.19,61.51) R117.1 R116.1 ; C115.2 v2(25.95,94.27) ; v2(24.68,136.94) 25.31,136.94 C167.2 ; v2(103.16,77.89) 103.29,78.02 103.29,78.79 C258.2 ; R124.1 155.99,84.11 v2(157.26,84.11) ; R383.2 v2(138.49,145.64) ; C142.2 145.2,34.33 v2(144.94,34.07) ; C248.2 v2(25.07,46.54) ; v1(81.23,93.13) 81.23,93.09 C96.2 ; C104.2 v2(89.45,25.82) ; 82.59,94.53 82.59,95.13 v2(82.77,95.31) ; v2(144.31,29.37) 144.94,30.01 C151.2 ; C108.2 87.67,26.45 v2(87.03,25.82) ; C237.2 v2(83.87,45.14) ; v2(63.73,66.46) 63.92,66.27 C73.2 ; R325.1 v2(137.58,37.38) ; 91.6,40.17 91.6,41.44 v2(90.97,42.07) ; C235.2 v2(93.62,46.92) ; v2(148.5,20.74) 148.37,20.61 C160.2 ; C68.2 v2(50.2,101.38) ; v1(86.6,87.4) 86.65,87.45 C46.2 ; C196.2 30.52,58.23 30.26,58.48 v2(30.26,59.09) ; C91.2 v2(93.64,42.33) ; R387.2 v2(145.64,143.36) ; 95.29,113.45 v2(95.29,112.69)
  BOTTOM w0.635: R406.1 31.79,56.17 v3(32.17,56.17) ; v2(84.24,99.86) 84.24,99.35 84.82,98.77 C274.2 ; C193.2 34.84,55.16 v3(34.2,55.16) ; C249.2 v2(100.16,106.92) ; C200.2 31.28,53.25 v3(32.17,54.14) 32.42,53.89 C194.2 ; v2(65.06,82.84) 66.08,82.84 66.57,83.33 C246.2 ; C199.2 31.91,55.16 v3(32.17,55.16) ; C257.2 90.91,105.62 90.91,106.78 v2(90.84,106.84) ; v2(136.11,15.35) 136.11,14.21 C157.2 ; C45.2 88.05,95.67 v2(87.92,95.54) ; C65.2 74.43,80.65 73.75,80.65 v2(73.7,80.6) 72.51,80.6 C56.2 ; v3(33.18,54.14) 33.18,53.5 C201.2 ; C207.2 34.84,53.5 v3(34.2,54.14) ; C198.2 33.18,56.68 v3(33.18,56.17) ; C16.2 v2(65.06,78.02) ; C23.2 v2(71.16,72.94) ; C247.2 52.16,82.42 v2(52.16,81.95) ; v2(69.13,80.94) 68.62,80.94 68.36,81.19 C52.2 ; C203.2 v2(126.4,126.91)
  BOTTOM w0.762: C240.2 90.99,33.42 v3(90.72,33.69) ; v3(88.18,32.42) 87.96,32.64 C254.2 ; v3(88.18,34.96) 88.09,34.87 C253.2 ; C250.2 88.98,35.43 v3(89.45,34.96) ; C252.2 90.42,32.13 v3(90.72,32.42)
  vias: v2(2.45,98.97) v2(2.45,96.43) v2(2.45,93.89) v2(2.45,91.35) v2(2.45,70.4) v2(2.45,67.86) v2(2.45,65.32) v2(2.45,59.6) v2(2.45,57.06) v2(2.45,54.52) v2(2.45,51.98) v2(2.45,49.44) v2(2.45,45.63) v2(2.45,43.09) v2(2.45,40.55) v2(2.45,27.22) v2(2.45,25.31) v2(2.45,23.41) v2(2.45,21.5) v2(2.45,19.6) v2(2.45,17.69) v2(2.45,15.79) v2(2.45,13.88) v2(2.45,11.98) v2(2.45,10.07) v2(2.45,8.17) v2(2.45,6.26) v2(2.45,4.36) v2(2.45,2.45) v2(4.36,157.39) v2(4.36,154.85) v2(4.36,152.31) v2(4.36,149.77) v2(4.36,147.23) v2(4.99,98.97) v2(4.99,96.43) v2(4.99,93.89) v2(4.99,91.35) v2(4.99,70.4) v2(4.99,67.86) v2(4.99,65.32) v2(4.99,59.6) v2(4.99,57.06) v2(4.99,54.52) v2(4.99,51.98) v2(4.99,49.44) v2(4.99,27.22) v2(4.99,25.31) v2(4.99,23.41) v2(4.99,21.5) v2(4.99,19.6) v2(4.99,17.69) v2(4.99,15.79) v2(4.99,13.88) v2(4.99,11.98) v2(4.99,10.07) v2(4.99,8.17) v2(4.99,6.26) v2(4.99,4.36) v2(4.99,2.45) v2(6.26,157.39) v2(6.26,154.85) v2(6.26,152.31) v2(6.26,149.77) v2(6.26,147.23) v2(7.53,70.4) v2(7.53,67.86) v2(7.53,27.22) v2(7.53,25.31) v2(7.53,23.41) v2(7.53,21.5) v2(7.53,19.6) v2(7.53,17.69) v2(7.53,15.79) v2(7.53,13.88) v2(7.53,11.98) v2(7.53,10.07) v2(7.53,8.17) v2(7.53,6.26) v2(7.53,4.36) v2(7.53,2.45) v2(8.17,157.39) v2(8.17,154.85) v2(8.17,152.31) v2(8.17,149.77) v2(8.17,147.23) v2(10.07,157.39) v2(10.07,154.85) v2(10.07,152.31) v2(10.07,149.77) v2(10.07,147.23) v2(10.07,70.4) v2(10.07,67.86) v2(10.07,27.22) v2(10.07,25.31) v2(10.07,23.41) v2(10.07,21.5) v2(10.07,19.6) v2(10.07,17.69) v2(10.07,15.79) v2(10.07,13.88) v2(10.07,11.98) v2(10.07,10.07) v2(10.07,8.17) v2(10.07,6.26) v2(10.07,4.36) v2(10.07,2.45) v2(11.98,157.39) v2(11.98,154.85) v2(11.98,152.31) v2(11.98,149.77) v2(11.98,147.23) v2(11.98,67.86) v2(12.61,58.33) v2(12.61,56.43) v2(12.61,54.52) v2(12.61,52.62) v2(12.61,11.34) v2(12.61,5.63) v2(13.88,157.39) v2(13.88,154.85) v2(13.88,152.31) v2(13.88,149.77) v2(13.88,147.23) v2(13.88,48.81) v2(13.88,46.27) v2(13.88,43.73) v2(13.88,39.28) v2(13.88,35.47) v2(13.88,33.57) v2(13.88,31.66) v2(13.88,29.76) v2(13.88,27.85) v2(13.88,25.95) v2(13.88,24.04) v2(13.88,22.14) v2(13.88,20.23) v2(13.88,18.33) v2(13.88,15.79) v2(13.88,8.8) v2(13.88,2.45) v2(14.52,67.86) v2(15.15,58.33) v2(15.15,56.43) v2(15.15,54.52) v2(15.15,52.62) v2(15.15,11.34) v2(15.15,5.63) v2(15.79,157.39) v2(15.79,154.85) v2(15.79,152.31) v2(15.79,149.77) v2(15.79,147.23) v2(15.79,95.16) v2(15.79,92.62) v2(15.79,90.08) v2(15.79,87.54) v2(16.42,39.28) v2(16.42,35.47) v2(16.42,33.57) v2(16.42,31.66) v2(16.42,29.76) v2(16.42,27.85) v2(16.42,25.95) v2(16.42,24.04) v2(16.42,22.14) v2(16.42,20.23) v2(16.42,18.33) v2(16.42,15.79) v2(16.42,8.8) v2(16.42,2.45) v2(17.06,83.73) v2(17.06,81.19) v2(17.06,78.65) v2(17.06,76.11) v2(17.06,72.94) v2(17.06,70.4) v2(17.06,67.86) v2(17.69,157.39) v2(17.69,154.85) v2(17.69,152.31) v2(17.69,149.77) v2(17.69,147.23) v2(17.69,11.34) v2(17.69,5.63) v2(18.33,97.7) v2(18.33,95.16) v2(18.33,92.62) v2(18.33,90.08) v2(18.33,87.54) v2(18.96,167.55) v2(18.96,165.65) v2(18.96,163.74) v2(18.96,39.28) v2(18.96,35.47) v2(18.96,33.57) v2(18.96,31.66) v2(18.96,29.76) v2(18.96,27.85) v2(18.96,25.95) v2(18.96,24.04) v2(18.96,22.14) v2(18.96,20.23) v2(18.96,18.33) v2(18.96,15.79) v2(18.96,8.8) v2(18.96,2.45) v2(19.6,157.39) v2(19.6,154.85) v2(19.6,152.31) v2(19.6,149.77) v2(19.6,147.23) v2(19.6,83.73) v2(19.6,81.19) v2(19.6,78.65) v2(19.6,76.11) v2(19.6,72.94) v2(19.6,70.4) v2(19.6,67.86) v2(19.6,51.35) v2(19.6,48.81) v2(19.6,46.27) v2(20.23,11.34) v2(20.23,5.63) v2(20.87,167.55) v2(20.87,165.65) v2(20.87,163.74) v2(20.87,97.7) v2(21.5,157.39) v2(21.5,154.85) v2(21.5,152.31) v2(21.5,149.77) v2(21.5,147.23) v2(21.5,39.28) v2(21.5,35.47) v2(21.5,33.57) v2(21.5,31.66) v2(21.5,29.76) v2(21.5,27.85) v2(21.5,25.95) v2(21.5,24.04) v2(21.5,22.14) v2(21.5,20.23) v2(21.5,18.33) v2(21.5,15.79) v2(21.5,8.8) v2(21.5,2.45) v2(22.14,109.51) v2(22.14,108.62) v2(22.14,107.73) v2(22.14,51.35) v2(22.14,48.81) v2(22.14,46.27) v2(22.77,167.55) v2(22.77,165.65) v2(22.77,163.74) v2(22.77,100.88) v2(23.02,109.51) v2(23.02,108.62) v2(23.02,107.73) v2(23.91,109.51) v2(23.91,108.62) v2(23.91,107.73) v2(24.04,158.03) v2(24.68,167.55) v2(24.68,165.65) v2(24.68,163.74) v2(24.68,27.85) v2(24.68,25.31) v2(25.31,100.88) v2(25.95,158.03) v2(26.58,167.55) v2(26.58,165.65) v2(26.58,163.74) v2(26.58,31.66) v2(27.22,27.85) v2(27.22,25.31) v2(27.22,20.23) v2(27.85,158.03) v2(27.85,151.04) v2(27.85,148.5) v2(27.85,101.51) v2(28.49,167.55) v2(28.49,165.65) v2(28.49,163.74) v2(29.76,158.03) v2(29.76,128.82) v2(29.76,126.91) v2(29.76,100.24) v2(29.76,38.01) v2(29.76,31.66) v2(29.76,20.23) v2(30.39,167.55) v2(30.39,165.65) v2(30.39,163.74) v2(30.39,151.04) v2(30.39,148.5) v2(30.39,101.51) v2(31.66,158.03) v2(31.66,38.01) v2(32.3,167.55) v2(32.3,165.65) v2(32.3,163.74) v2(32.3,128.82) v2(32.3,126.91) v2(32.3,100.24) v2(32.3,20.23) v2(33.57,158.03) v2(33.57,38.01) v2(34.2,167.55) v2(34.2,165.65) v2(34.2,163.74) v2(34.84,46.9) v2(34.84,45) v2(35.47,158.03) v2(35.47,151.68) v2(35.47,149.14) v2(35.47,146.6) v2(35.47,144.06) v2(35.47,141.52) v2(35.47,138.98) v2(35.47,137.07) v2(35.47,133.26) v2(35.47,131.36) v2(36.11,167.55) v2(36.11,165.65) v2(36.11,163.74) v2(36.11,39.28) v2(36.11,37.38) v2(36.11,35.47) v2(36.11,33.57) v2(36.11,31.66) v2(36.11,29.76) v2(36.11,27.85) v2(37.38,158.03) v2(38.01,151.68) v2(38.01,149.14) v2(38.01,146.6) v2(38.01,144.06) v2(38.01,141.52) v2(38.01,138.98) v2(38.01,137.07) v2(38.01,133.26) v2(38.01,131.36) v2(38.65,39.28) v2(38.65,37.38) v2(38.65,35.47) v2(38.65,33.57) v2(38.65,31.66) v2(38.65,29.76) v2(38.65,27.85) v2(38.65,25.95) v2(38.65,24.04) v2(38.65,22.14) v2(39.28,158.03) v2(40.55,144.06) v2(40.55,141.52) v2(40.55,138.98) v2(40.55,137.07) v2(40.55,133.26) v2(40.55,131.36) v2(41.19,158.03) v2(41.19,39.28) v2(41.19,37.38) v2(41.19,35.47) v2(41.19,33.57) v2(41.19,31.66) v2(41.19,29.76) v2(41.19,27.85) v2(41.19,25.95) v2(41.19,24.04) v2(41.19,22.14) v2(43.09,144.06) v2(43.09,141.52) v2(43.09,138.98) v2(43.09,137.07) v2(43.09,133.26) v2(43.09,131.36) v2(45.63,46.9) v2(45.63,44.36) v2(46.27,144.06) v2(46.27,141.52) v2(46.27,32.3) v2(46.27,30.39) v2(46.27,28.49) v2(46.27,26.58) v2(46.27,24.68) v2(46.27,22.77) v2(46.27,20.87) v2(46.27,18.96) v2(46.27,17.06) v2(46.27,15.15) v2(46.9,12.61) v2(46.9,10.07) v2(46.9,6.9) v2(46.9,4.36) v2(48.17,32.3) v2(48.17,30.39) v2(48.17,28.49) v2(48.17,26.58) v2(48.17,24.68) v2(48.17,22.77) v2(48.17,20.87) v2(48.17,18.96) v2(48.17,17.06) v2(48.17,15.15) v2(48.81,144.06) v2(48.81,141.52) v2(51.98,72.3) v2(51.98,69.76) v2(53.89,39.92) v2(53.89,37.38) v2(53.89,33.57) v2(53.89,31.03) v2(58.33,78.65) v2(58.33,76.11) v2(60.87,29.76) v2(61.51,38.01) v2(63.41,29.76) v2(63.41,5.63) v2(63.41,3.72) v2(63.41,1.82) v2(64.05,38.01) v2(65.95,29.76) v2(65.95,5.63) v2(65.95,3.72) v2(65.95,1.82) v2(68.49,29.76) v2(68.49,5.63) v2(68.49,3.72) v2(68.49,1.82) v2(71.03,5.63) v2(71.03,3.72) v2(71.03,1.82) v2(71.67,28.49) v2(71.67,25.95) v2(73.57,165.01) v2(74.21,28.49) v2(74.21,25.95) v2(75.48,165.01) v2(75.48,156.12) v2(76.75,158.03) v2(76.75,15.79) v2(77.38,165.01) v2(78.02,156.12) v2(79.29,165.01) v2(79.29,158.03) v2(79.29,15.79) v2(81.19,165.01) v2(81.19,149.14) v2(83.1,165.01) v2(83.73,149.14) v2(85,165.01) v2(85,9.44) v2(86.27,5.63) v2(86.27,3.72) v2(86.91,165.01) v2(87.54,144.69) v2(87.54,9.44) v2(88.81,165.01) v2(88.81,5.63) v2(88.81,3.72) v2(90.08,144.69) v2(90.72,166.92) v2(90.72,165.01) v2(91.35,5.63) v2(92.62,166.92) v2(93.89,5.63) v2(94.53,166.92) v2(96.43,166.92) v2(98.34,166.92) v2(98.34,20.87) v2(98.34,17.06) v2(98.34,15.15) v2(99.22,27.02) v2(100.24,166.92) v2(100.88,20.87) v2(100.88,17.06) v2(100.88,15.15) v2(102.15,166.92) v2(102.78,14.52) v2(104.05,166.92) v2(105.32,14.52) v2(105.96,166.92) v2(107.86,166.92) v2(109.77,166.92) v2(110.4,102.78) v2(111.04,121.83) v2(111.04,119.93) v2(111.04,118.02) v2(111.04,116.12) v2(112.31,166.92) v2(112.94,102.78) v2(113.58,121.83) v2(113.58,119.93) v2(113.58,118.02) v2(113.58,116.12) v2(114.21,37.38) v2(114.85,166.92) v2(114.85,32.3) v2(115.48,121.83) v2(115.48,119.93) v2(115.48,118.02) v2(115.48,116.12) v2(115.48,107.86) v2(115.48,105.96) v2(115.48,104.05) v2(115.86,127.16) v2(116.12,163.11) v2(116.12,161.2) v2(116.12,159.3) v2(116.12,39.92) v2(116.12,15.79) v2(116.75,37.38) v2(117.39,166.92) v2(117.39,32.3) v2(118.02,121.83) v2(118.02,119.93) v2(118.02,118.02) v2(118.02,116.12) v2(118.02,107.86) v2(118.02,105.96) v2(118.02,104.05) v2(118.66,163.11) v2(118.66,161.2) v2(118.66,159.3) v2(118.66,52.62) v2(118.66,50.08) v2(118.66,39.92) v2(118.66,15.79) v2(120.56,165.01) v2(121.2,15.79) v2(121.83,127.55) v2(122.47,157.39) v2(123.1,165.01) v2(123.1,149.14) v2(123.1,126.28) v2(124.37,127.55) v2(125.01,157.39) v2(125.64,149.14) v2(125.64,126.28) v2(126.28,65.95) v2(126.28,63.41) v2(127.55,18.96) v2(127.55,16.42) v2(127.55,13.88) v2(130.09,16.42) v2(130.09,13.88) v2(131.36,24.04) v2(131.36,22.14) v2(132.63,20.23) v2(133.9,24.04) v2(133.9,22.14) v2(133.9,3.72) v2(133.9,1.82) v2(135.17,20.23) v2(135.17,8.8) v2(135.17,6.9) v2(136.44,3.72) v2(136.44,1.82) v2(137.07,26.58) v2(137.07,24.04) v2(137.71,139.61) v2(137.71,8.8) v2(137.71,6.9) v2(138.98,35.47) v2(138.98,31.41) v2(140.25,139.61) v2(140.88,33.44) v2(142.91,35.47) v2(142.91,31.41) v2(147.23,67.86) v2(147.23,65.32) v2(147.23,60.24) v2(147.23,57.7) v2(148.12,143.55) v2(149.01,143.55) v2(150.28,143.55) v2(151.29,143.55) v2(152.56,143.29) v2(152.95,12.61) v2(153.58,48.81) v2(153.58,46.27) v2(153.58,43.73) v2(153.58,41.19) v2(153.58,32.93) v2(153.58,30.39) v2(153.58,27.85) v2(153.58,25.31) v2(154.6,145.22) v2(154.6,144.51) v2(154.6,143.78) v2(154.57,143.04) v2(154.85,11.34) v2(155.49,48.81) v2(155.49,46.27) v2(155.49,43.73) v2(155.49,41.19) v2(155.49,13.88) v2(156.12,34.84) v2(156.12,32.3) v2(156.12,29.76) v2(156.12,27.22) v2(156.25,144.18) v2(156.22,143.27) v2(157.39,48.81) v2(157.39,46.27) v2(157.39,43.73) v2(157.39,41.19) v2(157.39,13.88) v2(157.39,11.34) v2(157.39,8.8) v2(157.39,6.26) v2(158.03,32.3) v2(158.03,29.76) v2(158.03,27.22) v2(158.66,119.93) v2(158.66,118.02) v2(158.66,116.12) v2(158.66,114.21) v2(158.66,112.31) v2(158.66,110.4) v2(158.66,108.5) v2(158.66,106.59) v2(158.66,104.69) v2(158.66,102.78) v2(158.66,3.09) v2(159.93,34.84) v2(159.93,32.3) v2(159.93,29.76) v2(159.93,27.22) v2(160.57,142.79) v2(160.57,140.88) v2(160.57,138.98) v2(160.57,137.07) v2(160.57,135.17) v2(160.57,133.26) v2(160.57,131.36) v2(160.57,129.45) v2(160.57,127.55) v2(160.57,125.64) v2(161.2,3.09) v2(161.84,116.12) v2(161.84,114.21) v2(161.84,112.31) v2(161.84,110.4) v2(161.84,108.5) v2(161.84,106.59) v2(161.84,104.69) v2(161.84,102.78) v2(161.84,100.88) v2(161.84,98.97) v2(162.47,48.17) v2(162.47,46.27) v2(162.47,44.36) v2(162.47,42.46) v2(162.47,40.55) v2(162.47,38.65) v2(162.47,36.74) v2(162.47,34.84) v2(162.47,32.93) v2(162.47,31.03) v2(162.47,29.12) v2(162.47,26.58) v2(163.11,154.22) v2(163.11,152.31) v2(163.11,150.41) v2(163.11,148.5) v2(163.11,146.6) v2(163.11,144.69) v2(163.11,142.79) v2(163.11,140.88) v2(163.11,138.98) v2(163.11,137.07) v2(163.74,3.09) v2(164.38,116.12) v2(164.38,114.21) v2(164.38,112.31) v2(164.38,110.4) v2(164.38,108.5) v2(164.38,106.59) v2(164.38,104.69) v2(164.38,102.78) v2(164.38,100.88) v2(164.38,98.97) v2(165.01,48.17) v2(165.01,46.27) v2(165.01,44.36) v2(165.01,42.46) v2(165.01,40.55) v2(165.01,38.65) v2(165.01,36.74) v2(165.01,34.84) v2(165.01,32.93) v2(165.01,31.03) v2(165.01,29.12) v2(165.01,26.58) v2(165.65,154.22) v2(165.65,152.31) v2(165.65,150.41) v2(165.65,148.5) v2(165.65,146.6) v2(165.65,144.69) v2(165.65,142.79) v2(165.65,140.88) v2(165.65,138.98) v2(165.65,137.07) v2(166.28,3.09) v2(167.55,48.17) v2(167.55,46.27) v2(167.55,44.36) v2(167.55,42.46) v2(167.55,40.55) v2(167.55,38.65) v2(167.55,36.74) v2(167.55,34.84) v2(167.55,32.93) v2(167.55,31.03) v2(167.55,29.12) v2(167.55,26.58) v2(167.55,24.04) v2(167.55,21.5) v2(168.19,154.22) v2(168.19,152.31) v2(168.19,150.41) v2(168.19,148.5) v2(168.19,146.6) v2(168.19,144.69) v2(168.19,142.79) v2(168.19,140.88) v2(168.19,138.98) v2(168.19,137.07) v2(168.19,135.17) v2(168.19,133.26) v2(168.19,131.36) v2(168.19,129.45) v2(168.19,127.55) v2(168.19,125.64) v2(168.19,123.74) v2(168.19,121.83) v2(168.19,119.93) v2(168.19,118.02) v2(168.19,116.12) v2(168.19,114.21) v2(168.19,112.31) v2(168.19,110.4) v2(168.19,108.5) v2(168.19,106.59) v2(168.19,104.69) v2(168.19,102.78) v2(168.19,100.88) v2(168.19,98.97) v3(33.18,55.16) v3(34.2,56.17) v3(89.45,33.69) v3(89.45,32.42)

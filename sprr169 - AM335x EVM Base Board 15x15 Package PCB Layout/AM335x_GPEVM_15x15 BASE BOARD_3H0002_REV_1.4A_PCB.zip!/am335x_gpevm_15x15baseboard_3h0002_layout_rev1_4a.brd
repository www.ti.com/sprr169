# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_4a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17564916: length 160
  TOP w0.121: v2(36.64,113.07) 36.64,114.49 37.5,115.35 v2(39.15,115.35) 39.15,113.67 39.19,113.63 39.19,113.6 39.45,113.34 40.14,113.34 40.82,114.01 42.75,114.01 43.53,114.79 43.78,114.79 44.6,115.61 R92.1 ; v2(10.58,76.08) R94.2 10.57,75.21 Q4.G ; R91.1 73.51,97.64 73.51,98.53 72.8,99.23 72.47,99.23 72.47,99.23 71.88,99.23 71.87,99.23 71.46,99.23 71.45,99.23 71.28,99.23 71.03,99.48 71.03,101.38 68.73,103.68 67.23,103.68 66.71,103.16 60.51,103.16 60.26,102.91 54.17,102.91 52.9,104.18 42.86,104.18 41.19,102.5 35.93,102.5 35.9,102.53 v2(35.44,102.53) 34.78,102.53 34.76,102.5 23.51,102.5 v2(23.28,102.27) ; v2(46.52,136.56) 47.28,135.8 54.52,135.8 55.28,135.04 56.17,135.04 57.44,133.77 58.84,133.77 v2(59.6,133.01)
  BOTTOM w0.121: v2(36.64,113.07) 35.44,111.87 v2(35.44,102.53) ; v2(10.58,76.08) 10.58,81.44 10.32,81.7 10.32,96.25 13.04,98.97 19.01,98.97 22.31,102.27 v2(23.28,102.27) ; v2(46.52,136.56) 46.52,133.64 44.61,131.74 44.61,121.47 39.15,116.01 v2(39.15,115.35) ; R512.1 v2(59.6,133.01)
N17601395: length 83.4
  TOP w0.121: v2(64.91,95.31) 65.19,95.03 R349.2 ; U14.7 v2(21.85,126.38) ; v2(17.87,109.54) 17.31,108.98 R492.2
  LY3 w0.133: v2(17.87,109.54) 16.72,108.39 16.72,104.33 22.16,98.89 32.07,98.89 32.16,98.99 46.66,98.99 50.33,95.31 v2(64.91,95.31)
  BOTTOM w0.121: v2(21.85,126.38) 21.85,125.29 22.39,124.75 22.39,115.91 21.78,115.3 21.78,112.08 20.61,110.91 19.21,110.91 17.87,109.56 v2(17.87,109.54)
N17618848: length 9.8
  TOP w0.121: C212.2 22.12,58.22 Y3.1 24.92,58.22 26.3,56.85 26.3,56.07 26.96,55.41 29.42,55.41 29.48,55.36 U25.6
N17618850: length 8.9
  TOP w0.121: C204.2 22.79,53.76 23.15,54.12 Y3.2 24.92,54.12 26.09,55.28 26.74,55.28 26.86,55.16 29.29,55.16 29.5,54.96 U25.7
N17618867: length 6.7
  TOP w0.121: TP47.1 32.31,63.55 32.31,59.84 32.1,59.63 32.1,58.91 32.18,58.82 U25.45
N17619022: length 8.5
  TOP w0.121: U25.42 33.38,60.21 32.81,60.79 32.81,63.04 33.13,63.36 34.15,63.36 34.45,63.66 34.71,63.66 35.09,64.05 35.34,64.05 TP49.1
N17619024: length 7.5
  TOP w0.121: U25.43 32.98,58.88 33.03,58.92 33.03,59.28 32.98,59.33 32.98,60.26 32.56,60.69 32.56,63.14 33.06,63.64 33.67,63.64 TP48.1
N17619221: length 4.8
  TOP w0.121: U25.40 34.18,59.71 v2(34.58,60.11) R405.1 R479.1
  BOTTOM w0.121: v2(34.58,60.11) R405.1
N17619435: length 1.1
  BOTTOM w0.121: R395.2 TP50.1
N17619707: length 3
  TOP w0.121: R394.2 33.78,60.52 U25.41
N17619739: length 6.4
  TOP w0.121: U25.46 31.78,59.7 32.06,59.98 32.06,64.28 TP46.1
N17684279: length 4.4
  TOP w0.121: R239.1 v2(129.45,79.79)
  BOTTOM w0.102: J8.12 132.12,79.54 130.72,79.54
  BOTTOM w0.121: 130.72,79.54 129.7,79.54 v2(129.45,79.79)
N17684406: length 4.9
  TOP w0.121: v2(88.36,37.53) 88.36,37.44 88.45,37.36 U4.33
  BOTTOM w0.203: v2(88.36,37.53) 88.07,37.53 87.62,37.98 87.62,39.03 87.79,39.2 R63.1
N17710761: length 4.8
  TOP w0.102: v1(84.2,79.4) U2.J3
  BOTTOM w0.102: 84.2,77.4 v1(84.2,79.4)
  BOTTOM w0.121: R22.2 83.36,75.93 83.36,76.09 84.2,76.93 84.2,77.4
N17828529: length 2.5
  TOP w0.102: v1(83.35,77.63) 83.35,78.65 83,79 U2.G2
  BOTTOM w0.102: 83.12,77.4 v1(83.35,77.63)
  BOTTOM w0.121: 83.12,77.4 83.03,77.32 TP2.1
N18082443: length 93.1
  TOP w0.121: v2(58.74,154.84) 81.66,154.84 81.91,154.6 R328.2 ; U13.4 v2(28.18,118.08) ; v2(55.62,154.84) v2(32.84,154.84)
  BOTTOM w0.121: v2(32.84,154.84) 32.84,151.67 32.83,151.65 32.83,138.92 28.15,134.25 28.15,118.1 v2(28.18,118.08) ; v2(58.74,154.84) v2(55.62,154.84)
N18136628: length 2.7
  TOP w0.121: U7.7 139.67,71.98 v2(139.74,72.05)
  BOTTOM w0.121: v2(139.74,72.05) 139.74,70.9
N18365790: length 3
  TOP w0.203: v2(84.78,35.34) 85.02,35.1 85.71,35.1 85.72,35.09 U4.39
  BOTTOM w0.381: R57.1 84.65,35.47 v2(84.78,35.34)
N18368859: length 1.9
  TOP w0.203: R69.2 93.26,23.78 U6.7
N19410176: length 3.5
  TOP w0.121: v2(28.1,138.09) 27.76,138.43 U15.6
  BOTTOM w0.121: v2(28.1,138.09) 28.36,138.34 R518.1
N19410226: length 2.4
  TOP w0.121: U13.12 v2(19.02,118.73)
  BOTTOM w0.121: R519.1 18.4,118.73 v2(19.02,118.73)
N19440113: length 0.4
  TOP w0.121: U24.B2 U24.B1
N19440133: length 0.4
  TOP w0.121: U24.D2 U24.D1
N19440219: length 2.9
  TOP w0.102: U24.B3 U24.C4
  TOP w0.121: C264.1 155.59,144.71 U24.D4 U24.C4 ; U24.B3 U24.A3
N19490589: length 9.9
  TOP w0.102: 77.1,80.08 77.2,80.08 77.21,80.07 77.93,80.07 U2.A3
  TOP w0.121: 77.1,80.08 76.39,80.08 75.74,79.42 71.85,79.42 71.46,79.03 71.16,79.03 70.78,78.66 69.9,78.66 TP24.1
N19558182: length 2.1
  TOP w0.121: R544.1 59.97,35.65 U32.2
N19577113: length 3.4
  TOP w0.121: U4.26 91.25,37.21 91.41,37.38 v2(92.49,37.38)
  BOTTOM w0.121: v2(92.49,37.38) 92.11,36.99 92.11,36.36 91.86,36.11
N19577116: length 4.7
  TOP w0.121: U4.19 92.82,33.89 v2(93.38,34.45)
  BOTTOM w0.121: v2(93.38,34.45) 92.64,35.2 92.64,36.63 93,36.99 R60.1
N21001557: length 9.1
  TOP w0.121: SW5.2 6.8,45.52 7.07,45.25 v2(7.94,45.25) 7.94,44.54 6.8,43.4 SW5.1
  BOTTOM w0.121: v2(7.94,45.25) R156.2 R112.2
N21001559: length 8
  TOP w0.635: SW5.4 v2(10.8,45.45) ; SW5.3 10.8,43.25 v2(10.83,43.34)
  BOTTOM w0.121: R560.2 R559.1 10.83,45.48 v2(10.8,45.45) 10.8,43.38 v2(10.83,43.34)
N21339295: length 1.8
  TOP w0.121: Q5.D 128.6,160.95 129.39,161.73 R23.2
N21611030: length 1.9
  TOP w0.121: R1.1 60.86,100.76 U3.1

## Copper pours and planes (outline as drawn)
DGND on TOP: 155.36,146.34 154.6,146.34 154.09,145.83 154.09,143.8 153.96,143.67 153.07,143.67 152.95,143.8 152.95,144.56 152.44,144.56 151.42,145.58 147.48,145.58 147.36,145.45 147.36,142.91 147.74,142.53 156.37,142.53 156.5,142.66 156.5,146.34 156.37,146.34 156.25,146.21 156.25,145.83 155.99,145.58 155.99,144.06 155.1,144.06 155.1,145.83 155.36,146.09
DGND on LY2_GND: 1.27,1.27 1.27,168.73 168.73,168.73 168.73,1.27 41.25,1.27 41.18,1.34 41.18,1.78 40.75,2.21 39.84,2.21 39.52,1.89 39.52,1.34 39.46,1.27 27.69,1.27 27.55,1.41 27.33,1.41 27.23,1.31 27.23,1.27 26.31,1.27 26.19,1.38 25.97,1.38 25.86,1.27
DGND on LY5_GND: 1.27,1.27 25.87,1.27 25.97,1.37 26.39,1.37 26.48,1.27 27.24,1.27 27.34,1.37 27.59,1.37 27.69,1.27 39.38,1.27 39.52,1.41 40.65,1.41 40.78,1.27 40.91,1.39 41.06,1.39 41.19,1.27 168.73,1.27 168.73,168.73 1.27,168.73
V1_2D on TOP: 149.26,15.53 155.99,15.53 156.37,15.91 156.37,18.96 156.12,19.21 151.93,19.21 151.8,19.09 151.8,17.06 151.55,16.8 149.9,16.8 149.77,16.93 149.01,16.93 149.01,15.79
V1_8D on LY4: 134.78,125.64 137.68,125.64 137.96,125.36 137.96,116.93 137.65,116.62 134.83,116.62 134.28,116.06 134.28,50.08 134.07,49.87 132.45,49.87 132.24,50.08 132.24,87.69 131.63,88.3 130.03,88.3 129.83,88.51 129.83,122.34 130.01,122.52 133.92,122.52 134.53,123.13 134.53,125.39
V3_3D on TOP: 66.08,31.79 66.08,33.95 66.33,34.2 67.6,34.2 68.24,33.57 68.24,32.17 67.73,31.66 66.2,31.66
V3_3D on TOP: 113.96,24.93 112.05,24.93 111.92,24.8 111.92,23.91 111.67,23.66 110.65,23.66 110.65,22.64 110.78,22.52 113.83,22.52 113.96,22.64
V3_3D on BOTTOM: 111.42,22.01 113.58,22.01 113.96,22.39 113.96,24.68 113.7,24.93 111.29,24.93 111.16,24.8 111.16,22.26
V3_3D on LY4: 47.28,139.1 47.28,139.23 37.02,139.23 36.87,139.08 36.87,117.46 34.5,115.1 10.93,115.1 10.07,114.24 10.07,95.52 10.43,95.16 27.22,95.16 28.36,94.02 28.36,66.99 28.76,66.59 39.15,66.59 39.53,66.2 39.53,51.19 39.05,50.71 29.2,50.71 28.74,51.17 28.74,56.81 28.61,56.93 27.27,56.93 27.09,56.76 27.09,51.95 26.48,51.35 12.46,51.35 12.1,50.99 12.1,48.73 11.16,47.79 1.79,47.79 1.52,47.52 1.52,38.75 1.91,38.37 1.91,38.35 11.29,38.35 11.56,38.07 11.56,28.07 11.21,27.72 1.85,27.72 1.52,27.39 1.52,1.88 1.88,1.52 113.84,1.52 114.72,2.4 114.72,24.88 113.78,25.82 103.16,25.82 102.27,24.93 102.27,9.05 100.88,7.66 52.31,7.66 51.22,8.75 51.22,71.56 50.46,72.33 33.62,72.33 32.93,73.01 32.93,98.84 32.42,99.35 14.11,99.35 13.75,99.71 13.75,103.67 14.11,104.02 67.37,104.02 68.24,104.89 68.24,119.37 69.18,120.31 74.54,120.31 75.6,121.37 75.6,146.54 75.3,146.85 64.83,146.85 64.43,146.44 64.43,140.47 63.05,139.1
V5_0D on TOP: 155.1,147.87 155.36,147.61 155.36,146.98 153.33,146.98 152.82,146.47 152.82,144.94 152.69,144.82 152.44,144.82 151.42,145.83 147.36,145.83 146.85,146.34 146.85,147.99 147.48,148.63 152.06,148.63 152.82,147.87
V5_0D on LY4: 152.95,148.25 152.95,71.13 151.83,70.01 140.37,70.01 140.37,70.14 138.59,70.14 137.96,69.51 137.96,45.86 137.35,45.25 129.86,45.25 129.32,44.72 129.32,25.89 128.99,25.56 126.99,25.56 126.66,25.89 126.66,49.44 126.88,49.67 134.35,49.67 134.66,49.97 134.66,116.01 135.01,116.37 137.76,116.37 138.21,116.83 138.21,125.46 137.78,125.89 134.53,125.89 134.15,125.51 134.15,123.33 133.79,122.97 130.26,122.97 129.7,123.53 129.7,129.65 130.39,130.34 147.2,130.34 148.5,131.63 148.5,148.35 148.78,148.63 152.56,148.63
VBAT on TOP: 83.35,10.58 93.38,10.58 93.89,11.09 93.89,14.01 91.48,16.42 91.48,18.71 91.22,18.96 91.22,21.88 87.79,21.88 87.54,21.63 86.65,21.63 86.65,21.75 86.52,21.75 86.52,22.26 82.97,22.26 82.97,18.96 86.14,18.96 86.27,18.83 86.27,14.9 85.89,14.52 78.4,14.52 78.33,14.45 77.82,14.45 77,13.63 77,8.8 77.25,8.55 78.9,8.55 79.67,9.31 79.67,11.21 80.05,11.59 82.33,11.59
VBAT on TOP: 10.96,99.86 14.77,99.86 14.9,99.99 14.9,100.62 14.64,100.88 10.96,100.88
VBAT on TOP: 159.8,146.47 159.8,149.39 159.55,149.64 158.15,149.64 157.39,148.88 157.39,148.25 156.63,147.48 156.63,146.85 157.14,146.85 157.52,146.47
VBAT on LY4: 106.21,163.38 106.21,158.36 106.67,157.9 120.03,157.9 120.43,157.49 120.43,43.39 119.49,42.46 98.67,42.46 98.34,42.12 98.34,38.54 97.67,37.88 84.34,37.88 83.86,37.4 83.86,23.94 82.82,22.9 57.82,22.9 56.68,24.04 56.68,83.32 55.89,84.11 51.57,84.11 50.71,84.97 50.71,103.52 50.43,103.8 14.26,103.8 14.01,103.54 14.01,99.81 14.21,99.61 32.73,99.61 33.44,98.89 33.44,73.24 34.05,72.63 50.58,72.63 51.6,71.61 51.6,8.88 52.44,8.04 100.49,8.04 101.89,9.44 101.89,25.34 102.88,26.33 114.11,26.33 115.1,25.34 115.1,2.04 115.62,1.52 138.25,1.52 138.44,1.71 138.44,2.96 139.1,3.62 140.12,3.62 140.63,4.13 140.63,8.93 142.28,10.58 142.28,24.04 140.98,25.34 126.71,25.34 126.4,25.64 126.4,49.57 126.71,49.87 131.66,49.87 131.86,50.08 131.86,87.57 131.61,87.82 129.65,87.82 129.35,88.12 129.35,147.79 130.44,148.88 152.87,148.88 153.33,148.42 153.33,146.37 153.73,145.96 158.89,145.96 159.3,146.37 159.3,154.06 158.89,154.47 135.72,154.47 134.53,155.66 134.53,163.54 134.33,163.74 106.56,163.74
VBUS1_OTG_CAP on TOP: 153.38,161.15 153.38,156.91 154.09,156.2 159.6,156.2 159.9,156.5 159.9,160.13 158.66,161.38 153.61,161.38
VDD1_SMPS on TOP: 72.3,37.68 74.99,37.68 75.25,37.43 75.25,36.21 75.02,35.98 72.45,35.98 72.27,36.16 72.27,37.65
VDD1_SMPS on TOP: 80.43,43.34 81.7,43.34 82.21,43.85 82.21,46.33 80.05,46.33 80.05,43.73
VDD1_SMPS on LY3: 124.67,51.22 125.2,50.69 125.2,46.13 124.56,45.5 122.19,45.5 121.7,45.02 121.7,44.36 121.45,44.11 76.71,44.11 76.11,43.51 76.11,34.95 75.23,34.07 67.55,34.07 66.71,34.92 66.71,46.88 67.11,47.28 116.7,47.28 117.39,47.97 117.39,50.65 117.95,51.22
VDD2_SMPS on TOP: 68.74,49.06 69.51,49.06 69.89,48.68 70.65,48.68 71.03,48.3 71.28,48.3 71.41,48.17 71.41,47.54 71.16,47.28 70.78,47.28 70.27,46.77 69.89,46.77 69.76,46.9 69.76,47.79 69.63,47.92 68.74,47.92
VDD2_SMPS on TOP: 76.24,36.49 77.76,36.49 78.27,36.99 78.27,38.65 78.14,38.77 76.24,38.77 76.11,38.65 76.11,36.61
VDD2_SMPS on LY4: 76.29,39.03 75.98,38.72 75.98,33.3 75.31,32.63 72.8,32.63 72.43,33 72.43,48.58 72.07,48.93 69.55,48.93 69.25,48.63 69.25,29.8 69.57,29.48 77.45,29.48 78.14,30.17 78.14,38.56 77.68,39.03
VDD3_SMPS on TOP: 90.97,44.74 93.13,44.74 93.26,44.87 93.26,46.52 92.87,46.9 91.1,46.9 90.84,46.65 90.84,44.87
VDD3_SMPS on BOTTOM: 92.62,49.69 92.62,45 92.24,44.61 90.33,44.61 89.95,45 89.95,49.69 89.98,49.73 89.98,49.69
VDD_CORE on TOP: 67.02,74.08 68.34,74.08 68.56,73.86 68.56,73.44 68.43,73.31 67.67,73.31 66.02,71.66 66.02,71.22 65.72,70.92 64.75,70.92 64.63,71.04 64.63,71.69
VDD_CORE on TOP: 72.55,46.77 72.55,45.76 72.81,45.5 75.09,45.5 75.6,46.01 75.6,46.9 75.22,47.28 73.06,47.28
VDD_CORE on BOTTOM: 73.06,47.28 72.55,46.77 72.55,45.76 72.81,45.5 75.09,45.5 75.6,46.01 75.6,46.77 75.09,47.28
VDD_CORE on LY3: 85.38,83.86 86.91,83.86 87.03,83.73 87.03,75.86 86.02,74.84 78.14,74.84 77.63,74.33 77.63,70.01 77.38,69.76 64.55,69.76 64.17,70.14 64.17,77.89 64.81,78.52 75.22,78.52 77.38,80.68 82.21,80.68
VDD_CORE on LY4: 82.33,86.81 82.33,81.67 82.43,81.57 85.91,81.57 86.02,81.68 86.02,82.11 86.24,82.33 86.68,82.33 86.78,82.43 86.78,83.85 86.91,83.98 88.37,83.98 88.56,84.17 88.56,88.49 88.37,88.68 85.32,88.68 84.43,87.79 83.92,87.79 83.1,86.97 82.49,86.97
VDD_MPU on TOP: 72.25,34.96 74.56,34.96 74.92,34.61 74.92,32.98 74.61,32.68 73.87,32.68 73.29,33.26 72.3,33.26 72.17,33.39 72.17,34.89
VDD_MPU on LY3: 84.37,88.43 84.62,88.18 84.62,87.79 84.24,87.41 84.24,85.25 83.73,84.75 82.33,84.75 81.83,84.24 81.83,83.86 81.19,83.22 80.3,83.22 80.17,83.1 78.14,83.1 75.86,80.81 67.22,80.81 66.97,80.56 64.55,80.56 64.43,80.68 64.43,82.71 73.06,82.71 74.21,83.86 76.11,83.86 79.03,86.78 79.54,86.78 79.92,86.4 80.43,86.4 80.94,85.89 81.44,86.4 81.44,88.43
VDDH_PHY on TOP: 27.28,52.74 28.36,52.74 29.18,53.57 30.26,53.57 30.26,53.95 28.49,53.95 28.04,53.5 27.28,53.5
VDDH_PHY on LY3: 25.95,58.46 25.95,53.13 26.18,52.89 29.26,52.89 29.5,53.14 29.5,58.36 29.13,58.74 26.22,58.74 25.95,58.46
VDDS_DDR on LY3: 67.09,69.07 67.09,54.52 67.35,54.27 103.67,54.27 105.19,55.79 105.19,65.7 106.46,66.97 106.46,69.68 106.01,70.14 104,70.14 103.36,69.51 91.5,69.51 90.49,68.49 90.49,66.41 89.57,65.49 89.06,65.49 89.06,66.66 87.79,67.93 87.79,69.51 85.05,69.51 86.93,67.63 86.93,65.82 86.91,65.8 86.35,65.8 86.32,65.82 86.32,66.89 83.7,69.51 67.53,69.51
VDDS_RTC on LY4: 80.43,82.9 80.43,80.62 70.13,80.62 69.82,80.92 69.82,81.83 71.6,83.6 79.73,83.6
VDDSHV2 on LY3: 19.87,113.04 19.87,110.65 22.59,107.94 42.07,107.94 47.64,113.5 76.44,113.5 76.85,113.91 79.49,113.91 80.71,115.12 80.71,118.78 79.74,119.75 78.8,119.75 78.73,119.67 77.79,119.67 77.41,119.29 77.41,118.38 77.94,117.84 77.94,116.42 77.67,116.15 73.23,116.15 73.14,116.06 43.93,116.06 43.6,116.39 42.02,116.39 38.11,112.48 23.25,112.48 22.52,113.22 20.05,113.22
VDDSHV4 on LY4: 42.2,144.08 42.2,164.3 42.79,164.88 61.12,164.88 61.51,164.5 61.51,163.97 61.86,163.61 105.65,163.61 105.96,163.31 105.96,158.1 106.41,157.64 116.78,157.64 117,157.42 117,149.11 116.65,148.75 114.64,148.75 114.34,149.06 114.34,155.08 113.93,155.49 77.15,155.49 76.62,154.95 76.62,147.76 76.08,147.23 58.15,147.23 57.7,146.77 57.7,143.88 57.49,143.67 42.61,143.67
VDDSHV6 on LY4: outline of 96 points within 1.52,1.52 168.45,168.47
AM335X_VDDS on LY3: 80.56,81.95 80.56,80.91 82.18,80.91 85.38,84.11 87.29,84.11 87.29,81.63 87.41,81.51 88.62,81.51 88.68,81.57 88.68,83.79 89.38,83.79 89.38,85.13 88.81,85.13 88.56,85.38 88.56,88.43 88.68,88.56 89.57,88.56 89.83,88.3 91.48,88.3 92.49,89.32 93.99,89.32 94.14,89.47 94.14,90.46 94.02,90.59 91.92,90.59 90.84,89.51 85.7,89.51 85.57,89.64 85.57,94.14 85.59,94.16 85.59,95.09 87.39,96.89 87.39,97.4 87.77,97.78 88.23,97.78 88.65,98.2 88.65,98.75 87.92,99.48 84.03,99.48 83.1,98.54 83.1,93 81.95,93 80.68,91.73 80.68,88.94 81.06,88.56 84.37,88.56 84.75,88.18 84.75,87.67 84.37,87.29 84.37,85.13 83.86,84.62 82.46,84.62 81.95,84.11 81.95,83.6 81.83,83.48 81.83,83.35 81.44,82.97 81.44,82.33 81.25,82.14 80.75,82.14
AM335X_VDDS_DDR on TOP: 96.11,73.37 96.11,72.95 96.25,72.81 98.07,72.81 98.17,72.91 98.17,73.37 98.11,73.43 96.17,73.43
AM335X_VDDS_DDR on BOTTOM: 81.32,80.81 83.73,80.81 83.98,80.56 86.78,80.56 86.91,80.68 86.91,81.19 86.78,81.32 83.98,81.32 83.86,81.44 83.86,81.83 83.6,82.08 81.32,82.08 81.19,81.95 81.19,80.94
AM335X_VDDS_DDR on LY4: 82.33,81.32 82.33,80.56 87.79,80.56 87.79,81.16 88.08,81.44 88.56,81.44 88.56,81.98 88.81,82.23 89.29,82.23 89.83,81.7 92.62,81.7 92.62,82.87 92.42,83.07 92.01,83.07 91.88,83.2 91.88,83.25 91.27,83.86 87.02,83.86 86.91,83.75 86.91,82.28 86.83,82.21 86.23,82.21 86.14,82.12 86.14,81.39 86.07,81.32
AM335X_VDDSHV3 on LY3: 89.45,88.43 88.75,88.43 88.62,88.3 88.62,86.52 88.87,86.27 91.73,86.27 92.37,86.91 92.87,86.91 93.51,87.54 94.14,87.54 94.27,87.67 94.27,88.94 94.14,89.06 92.49,89.06 91.48,88.05 89.83,88.05
AM335X_VDDSHV6 on LY3: 48.93,83.98 66.84,83.98 67.86,82.97 72.94,82.97 74.14,84.17 76.05,84.17 79.03,87.16 79.54,87.16 80.05,86.65 80.43,86.65 80.81,86.27 81.06,86.27 81.32,86.52 81.32,88.43 80.94,88.43 80.17,89.19 80.17,91.99 79.54,92.62 78.27,92.62 75.67,90.02 75.67,88.24 73.57,86.14 48.96,86.14 48.81,85.99 48.81,84.11
AM335X_VDDSHV6 on LY4: 88.81,82.08 89.22,82.08 89.45,81.85 89.45,81.7 89.57,81.57 92.56,81.57 92.62,81.51 92.62,79.89 92.71,79.79 93.31,79.79 93.38,79.72 93.38,79.15 93.26,79.03 91.28,79.03 91.1,78.85 91.1,76.95 90.96,76.81 80.83,76.81 80.56,77.08 80.56,88.99 80.76,89.19 82.84,89.19 83.1,88.94 83.1,87.33 82.92,87.16 82.21,87.16 82.21,80.44 82.35,80.3 87.76,80.3 87.92,80.47 87.92,81.06 88.18,81.32 88.56,81.32 88.68,81.44 88.68,81.95
HDMI_AVCC12 on TOP: 154.22,19.6 158.53,19.6 158.66,19.72 158.66,21.37 157.9,22.14 154.6,22.14 154.22,21.75
HDMI_CVCC12 on LY4: 132.63,25.97 132.63,32.75 132.8,32.93 135.42,32.93 135.8,33.31 135.8,34.15 135.5,34.45 134.86,34.45 134.66,34.66 134.66,39.28 134.91,39.53 142.18,39.53 142.4,39.31 142.4,35.32 142.76,34.96 147.41,34.96 147.61,34.76 147.61,30.8 147.33,30.52 146.67,30.52 146.34,30.19 146.34,28.92 146.77,28.49 149.64,28.49 152.13,26 152.13,19.8 151.37,19.04 142.79,19.04 142.68,19.14 142.68,24.27 141.26,25.69 132.9,25.69
HDMI_IOVCC on LY4: 135.39,33.18 132.78,33.18 132.63,33.34 132.63,41.13 132.8,41.31 149.39,41.31 149.64,41.06 149.64,29.04 149.36,28.76 146.82,28.76 146.6,28.99 146.6,30.09 146.77,30.26 147.41,30.26 147.87,30.72 147.87,34.76 147.41,35.22 143.24,35.22 142.66,35.8 142.66,39.41 142.28,39.79 134.78,39.79 134.4,39.41 134.4,34.48 134.68,34.2 135.42,34.2 135.55,34.07 135.55,33.34
LDO_VRTC on TOP: 82.59,25.95 83.86,25.95 83.86,23.02 83.73,22.9 82.71,22.9 82.59,22.77 81.83,22.77 81.83,24.29 82.59,25.06
PWR_SMPS3 on TOP: 89.06,38.44 89.06,36.74 89.45,36.74 89.45,38.21 89.88,38.65 89.88,39 89.62,39.25 89.39,39.25 89.22,39.08 89.22,38.59
PWR_SWIO on TOP: 94.91,29.88 96.43,29.88 96.56,30.01 96.56,35.09 95.29,35.09 94.02,33.82 94.02,32.17 93.76,31.91 93.51,31.91 93.51,31.66 94.02,31.66 94.14,31.53 94.14,30.64
PWR_VAUX33 on LY4: 87.03,28.87 87.03,27.98 87.41,27.6 94.14,27.6 94.65,28.1 94.65,28.87 94.27,29.25 90.33,29.25 89.95,28.87
PWR_VDAC on TOP: 97.7,36.74 97.7,35.22 94.02,35.22 93.64,34.84 91.99,34.84 91.99,35.34 93,35.34 94.14,36.49 94.91,36.49 95.16,36.74
PWR_VDD1_SMPS on TOP: 80.17,41.31 81.95,41.31 82.46,41.82 87.41,41.82 88.05,41.19 88.18,41.19 88.56,40.8 89.32,40.8 89.32,45.38 88.81,45.88 83.1,45.88 82.46,45.25 82.46,43.6 81.83,42.96 80.43,42.96 80.05,42.58 80.05,41.44
PWR_VDD2_SMPS on TOP: 84.11,32.8 84.11,33.06 84.49,33.44 85.64,33.44 85.89,33.18 86.4,33.18 86.4,32.93 85.76,32.93 85.64,33.06 85.25,33.06 85,32.8
PWR_VDD2_SMPS on TOP: 76.49,35.98 77.76,35.98 79.03,37.25 80.81,37.25 80.94,37.12 80.94,31.91 80.56,31.53 79.54,31.53 77.89,33.18 76.75,33.18 76.49,33.44
PWR_VDD3_SMPS on TOP: 89.57,36.74 89.57,38.14 90.21,38.77 90.21,38.9 90.52,39.22 91.35,39.22 91.35,44.23 91.48,44.36 93.13,44.36 93.26,44.23 93.26,39.03 93,38.77 90.84,38.77 90.46,38.39 90.21,38.39 89.83,38.01 89.83,36.74
PWR_VDDIO on TOP: 93,30.39 93,30.64 92.62,31.03 91.6,31.03 91.6,30.26 92.24,30.26 92.49,30.01 92.62,30.01
PWR_VDIG2 on TOP: 87.92,27.47 87.92,28.36 88.3,28.74 88.3,29.63 88.68,30.01 88.94,30.01 88.94,27.47
PWR_VIO_SMPS on TOP: 97.57,35.09 97.57,29.88 97.83,29.63 99.48,29.63 99.73,29.37 99.73,27.98 99.86,27.85 102.65,27.85 102.91,28.1 102.91,30.14 100.24,32.8 100.24,34.96 100.11,35.09
PWR_VIO_SMPS on BOTTOM: 93.13,32.8 96.18,32.8 96.56,32.42 100.88,32.42 101.26,32.04 101.26,30.9 100.75,30.39 95.54,30.39 94.02,31.91 93.13,31.91
PWR_VMMC on TOP: 86.02,28.1 86.27,28.1 86.52,28.36 86.52,29.5 87.41,30.39 87.41,30.96 87.48,31.03 87.79,31.03 87.79,29.88 87.67,29.76 87.41,29.76 87.29,29.63 87.29,27.47 87.16,27.34 86.02,27.34
PWR_VPLL on TOP: 93.26,36.87 92.49,36.87 92.24,36.61 92.24,35.85 92.75,35.85 92.75,36.36 93,36.61 93.26,36.61
USB5V_FB on TOP: 155.36,146.85 153.45,146.85 153.07,146.47 153.07,144.06 153.33,143.8 153.83,143.8 153.96,143.93 153.96,145.83 154.6,146.47 155.36,146.47
VADDL_PHY on TOP: 27.24,64.71 29.04,64.71 29.32,64.98 29.32,66.36 29.15,66.53 27.49,66.53 27.09,66.13 27.09,64.86
VADDL_PHY on LY4: 29.27,50.96 38.85,50.96 39.28,51.4 39.28,66.13 39.08,66.33 28.69,66.33 28.49,66.13 28.49,63.82 28.76,63.54 37.5,63.54 37.63,63.41 37.63,54.14 37.38,53.89 35.72,53.89 35.47,54.14 35.47,59.22 35.22,59.47 29.55,59.47 29.37,59.3 29.37,56.81 28.99,56.81 28.99,51.24
VBCKUPBAT on TOP: 92.75,38.39 92.24,38.39 91.73,37.88 91.1,37.88 90.72,37.5 90.72,36.61 90.97,36.61 90.97,37.25 91.35,37.63 92.37,37.63 92.75,38.01
VETH_LX on TOP: 27.98,57.95 27.98,56.68 28.05,56.6 29.17,56.6 29.35,56.43 30.26,56.43 30.26,56.68 29.76,56.68 29.32,57.11 29.12,57.11 28.87,57.36 28.87,57.76 29.12,58.01 29.12,59.22 28.87,59.47 28.36,59.47 27.34,60.49 27.34,62.27 27.09,62.52 26.2,62.52 26.2,60.36 26.45,60.11 26.45,59.47
VETH_VDDIO on LY4: 25.39,51.73 26.45,51.73 26.83,52.11 26.83,57.06 27.02,57.25 29.06,57.25 29.12,57.31 29.12,59.4 29.45,59.73 35.37,59.73 35.72,59.37 35.72,54.29 35.88,54.14 37.15,54.14 37.38,54.37 37.38,63.03 37.12,63.28 28.76,63.28 28.49,63 28.49,61.99 27.75,61.25 25.39,61.25 25.18,61.05 25.18,51.93
VPWRIN_FUSED on TOP: 65.95,8.8 75.73,8.8 76.49,9.56 76.49,13.88 74.59,15.79 74.59,22.39 64.05,22.39 63.54,21.88 63.54,11.21
VPWRIN_JCK on TOP: 51.6,12.36 56.81,12.36 58.97,14.52 58.97,20.99 58.2,21.75 51.98,21.75 50.96,20.74 50.96,13.5 51.6,12.86
VPWRIN_PREFUSE on TOP: 52.11,23.41 69.25,23.41 70.01,24.17 70.01,28.49 69.38,29.12 52.36,29.12 51.47,28.23 51.47,24.04
VRTC on TOP: 92.49,24.17 90.08,24.17 89.57,23.66 85.51,23.66 85.51,24.42 84.62,24.42 84.62,25.82 84.75,25.95 85.89,25.95 86.78,25.06 91.99,25.06 92.49,24.55
VRTC on LY3: 83.14,23.41 97.28,23.41 97.83,23.95 97.83,41.86 97.23,42.46 83.22,42.46 82.71,41.95 82.71,31.58 83.14,31.15 91.01,31.15 91.48,30.69 91.48,26.49 90.8,25.82 83.02,25.82 82.71,25.51 82.71,23.83
VUSB_VBUS0 on TOP: 131.74,166.51 131.74,164.98 131.61,164.86 131.61,162.44 132.12,162.44 132.12,163.46 132.88,164.22 134.15,164.22 134.15,165.11 132.63,165.11 132.37,165.37 132.37,166.51
VUSB_VBUS0 on TOP: 132.75,148.82 136.69,148.82 136.69,152.63 135.67,153.64 132.5,153.64 132.5,149.07
VUSB_VBUS0 on BOTTOM: 135.17,167.8 127.04,167.8 126.66,167.42 126.66,164.25 127.29,163.61 130.34,163.61 130.47,163.49 130.47,161.71 131.48,160.69 132.38,160.69 132.74,160.32 132.76,160.32 132.82,160.26 132.82,151.61 133.32,151.1 137.01,151.1 138.15,152.25 138.15,164.82
VUSB_VBUS1 on TOP: 140.82,148.37 145.07,148.37 145.07,152.82 144.94,152.95 141.01,152.95 140.75,152.69 140.75,148.44
VUSB_VBUS1 on TOP: 147.17,162.53 147.17,161.58 147.67,161.58 147.67,162.6 148.44,163.36 149.95,163.36 150.48,162.83 150.48,156.73 150.99,156.22 153,156.22 153,164.3 151.01,166.28 148.12,166.28 147.99,166.15 147.99,164.25 147.87,164.12 147.23,164.12 146.98,163.87 146.98,162.72
VUSB_VBUS1 on BOTTOM: 141.01,148.44 144.92,148.44 145.07,148.59 145.07,151.68 149.01,155.61 153.07,155.61 153.64,156.18 153.64,165.07 151.04,167.68 141.71,167.68 140.88,166.85 140.88,148.56
N19440113 on TOP: 160.31,153.07 156.5,153.07 156.5,148.12 156.12,147.74 156.12,146.98 156.25,146.85 156.37,146.85 156.5,146.98 156.5,147.48 157.26,148.25 157.26,149.01 158.28,150.02 160.31,150.02
N19440133 on TOP: 155.23,152.95 151.17,152.95 151.17,149.9 153.07,147.99 155.1,147.99 155.49,147.61 155.49,146.98 155.74,146.98 155.74,147.87 155.23,148.37

Small or netless copper shapes (teardrops, artwork): 4 on TOP

## Text on the board
BOTTOM: LAYER6 - SECONDARY SIDE | 6 | PN 3H0002
User.Comments: sdf | Green indicates power/gnd routing
TOP: LAYER1 - PRIMARY SIDE | 1 | 6
Ref Des/Silkscreen Top: E4 | A4 | VBAT | 1 | GND | RESET | INT | VDDS_SRAM_CORE | VDDS_SRAM_MPU_BB | VDDA_ADC | VDDSHV6 | 5VDC | 2.5A | VDDS_RTC | VDDS_PLL_DDR | VDD CORE | ON | POWER | OFF | VDDSHV5V | VDDS | 3.0V 800uA | VDDA3P3V_USB0 | RS-232 0 | VDDSHV2 | VDDA1P8V_USB0 | USB0 | VDDSHV3 | HDMI | USB1 | COM | SD/MMC0 Card | VDDS_PLL_MPU | VDDS_DDR | VDDS_PLL_CORE_LCD | VDDS_OSC | VDDSHV1 | VDDSHV4 | SYSBOOT 0-7 | SYSBOOT 8-15 | ARM MPU | AM335X ZCZ BASE BOARD | REV 1.4A | SN#:_________________ | ASSY PN 4P0016 | UL 94V0
LY3: LAYER 3 - SINGAL 1 | 3 | 6
LY4: LAYER 4 - SIGNAL 2 | 4 | 6
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | UNLESS OTHERWISE SPECIFIED | DIMENSIONS ARE IN INCHES | TOLERANCES ON; | 2 PL DECIMALS + | 3 PL DECIMALS + | ANGLES + | FRACTIONS + | SIGNATURES | DATE | SCALE | SIZE | 1:1 | SHEET 1 OF 1 | 1.4A | REV | PRODUCTION RELEASE | AM335x EVM GENERAL PURPOSE ZCZ BASE BOARD 1.4A | DESCRIPTION | REVISIONS | FABRICATION DRAWING | 07/18/2012 | APPROVED | TEXAS INSTRUMENTS | D | C | B | A | 4 | 3 | 2
DIMENSION: FAB DRAWING | 1 | 9. PLATED THROUGH SLOT INDICATED WITH MULTIPLE DRILL HITS SHOULD BE | 11. DESIGN HAS INTENTIONAL SHORTS AT SENSE RESISTORS AS SHOWN IN IPC356 NETLIST. | PROCESS NOTES: | 2. APPLY LPI SOLDERMASK OVER BARE COPPER (SMOBC), | COLOR: GREEN. SOLDERMASK SHALL | CONFORM TO IPC-SM-840, CLASS H. CURRENT REV. | 3. SOLDERMASK ARTWORK HAS ZERO (0) OVERSIZED PADS. | FABRICATION VENDOR IS ALLOWED TO ADJUST THE COMPONENT | SOLDERMASK PADS TO MEET THEIR TOOLING REQUIREMENTS. | 4. APPLY LPI SILKSCREEN OR EQUIVALENT PER THE ARTWORK. | COLOR: WHITE. | 1. PLATE ALL EXPOSED AREAS WITH ELECTROLESS | IMMERSION GOLD, NICKEL 150 MICROINCHES THK MIN | GOLD 5-15 MICROINCHES THK MIN. | 10. ALL VIAS TO HAVE SOLDERMASK. | FAB NOTES: | 1. ALL DIMENSIONS ARE IN INCHES, UNLESS | OTHERWISE NOTED. | 2. THE PWB SHALL BE FABRICATED TO IPC-6012, | CLASS 2 AND WORKMANSHIP SHALL CONFORM TO | IPC-A-600, CLASS 2. CURRENT REVISIONS. | 3. BOARD MATERIAL SHALL BE 180 Tg/350 Td ISOLA FR-370HR | OR EQUIVALENT, RoHS COMPLIANT AND LEAD FREE | ASSEMBLY CAPABLE.  BOARD MATERIAL SHALL | MEET OR EXCEED IPC-4101B. COLOR: NATURAL. | 4. BOARD MATERIAL & CONSTRUCTION TO BE U.L. | APPROVED AND MARKED ON THE FINISHED BOARD. | 5. MINIMUM COPPER WALL THICKNESS OF PLATED-THRU | HOLES TO BE .001 INCH, WITH A MINIMUM | ANNULAR RING OF .002 INCH. | 6. OVERALL BOARD THICKNESS TO BE .062 +/- 10% | AND APPLIES AFTER ALL LAMINATION AND PLATING | PROCESSES, MEASURED FROM COPPER TO COPPER. | 7. MAX. WARP & TWIST TO BE .0075 INCHES PER INCH. | 8. BOARD MUST BE ELECTRICALLY TESTED USING | SUPPLIED IPC-D-356 NETLIST. | FINISHED AS SMOOTH WALL BY VEDOR. | (OZ) | LAYER 1 - PRIMARY SIDE - SIGNAL | LAYER 2 - GROUND PLANE | LAYER 3 - SIGNAL | LAYER 4 - SIGNAL | LAYER 5 - SPLIT POWER PLANE | LAYER 6 - SECONDARY SIDE - SIGNAL | LAYER# | COPPER WEIGHT | HALF+PLATING | IMPEDANCE CONTROL | +/- 10% | 50ohm SINGLE ENDED | TRACE WIDTH | 5.25 | 4.75 | TRACE WIDTH / SPACE | 90ohm DIFFERENTIAL | 4.5/6.5 | 5.0/7.0 | 100ohm DIFFERENTIAL | 3.75/7.25 | 4.00/8.00 | IMEPDANCE TABLE - MILS
DEVICE_TYPE_TOP: J6 | J4 | J3 | J1
User.7: LAYER 2 - GND PLANE | 2 | 6
User.9: LAYER 5 - POWER PLANE | 5 | 6
User.10: LAYER 6 - SIGNAL 2 | 6
User.11: LAYER 7 - GND PLANE 2 | 7 | 6
User.12: SOLDERMASK BOTTOM | 2
User.13: SOLDERMASK TOP | 1 | 2
User.14: PASTEMASK BOTTOM | 2
User.15: PASTEMASK TOP | 1 | 2
User.16: SILKSCREEN BOTTOM | 2
User.17: SILKSCREEN TOP | 1 | 2
User.20: ASSEMBLY TOP | 1 | 2
User.21: 2 | OF | SH | ASSEMBLY BOTTOM | TI-6033-01 | PRJ# | DESCRIPTION | 07-23-12 | DATE | TEXAS INSTRUMENTS | REV | 1.4A | 3H0002 | CUSTOMER NAME  : | BOARD NO : | BOARD NAME | AM335x ZCZ BASEBOARD
User.22: 3H0002 | TEXAS INSTRUMENTS | 1.4A | 07-21-12 | TI-6033-01 | AM335x ZCZ BASEBOARD
User.26: FIGURE | SIZE | 8.0 | 10.0 | 18.0 | 26.0 | 35.0 | 36.0 | 40.0 | 43.0 | 50.0 | 62.0 | 63.0 | 91.0 | 120.0 | 125.0 | 140.0 | 33.0 | 61.0 | 70.0 | 110.0 | 250.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | PLATED | NON-PLATED | QTY | 185 | 2644 | 18 | 60 | 10 | 4 | 226 | 9 | 6 | 2 | 1

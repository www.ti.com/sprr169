# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_LAYOUT_REV1_6A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_TX0+: length 27.6
  TOP w0.095: U10.62 140.13,27.87 140.02,27.76 140.02,24.18 138.7,22.86 138.7,21.51 139.86,20.35 139.86,16.8 142.15,14.51 142.37,14.51 142.55,14.7 U11.18 144.52,14.7 144.69,14.53 146.14,14.53 148.8,11.87 148.8,9.71 148.89,9.61 149.06,9.61 149.16,9.52 J10.7
HDMI_TX0-: length 27.6
  TOP w0.095: U10.61 139.63,27.87 139.74,27.76 139.74,24.3 138.42,22.97 138.42,21.4 139.58,20.23 139.58,16.69 142.04,14.23 142.37,14.23 142.55,14.05 U11.17 144.74,14.05 144.94,14.25 146.02,14.25 148.52,11.75 148.52,9.71 148.42,9.61 148.25,9.61 148.16,9.52 J10.9
HDMI_TX1+: length 27.6
  TOP w0.095: J10.4 150.66,9.52 150.56,9.61 150.39,9.61 150.3,9.71 150.3,11.79 145.63,16.46 144.55,16.46 144.37,16.65 U11.21 142.55,16.65 142.37,16.46 142.11,16.46 140.63,17.94 140.63,21.06 139.89,21.79 139.89,22.58 141.52,24.21 141.52,27.76 141.63,27.87 U10.65
HDMI_TX1-: length 27.6
  TOP w0.095: J10.6 149.66,9.52 149.75,9.61 149.92,9.61 150.02,9.71 150.02,11.68 145.51,16.18 144.55,16.18 144.37,16 U11.20 142.55,16 142.37,16.18 141.99,16.18 140.35,17.83 140.35,20.94 139.61,21.68 139.61,22.69 141.24,24.32 141.24,27.76 141.13,27.87 U10.64
HDMI_TX2+: length 27.6
  TOP w0.095: J10.1 152.16,9.52 152.06,9.61 151.89,9.61 151.8,9.71 151.8,11.61 145.65,17.76 144.55,17.76 144.37,17.95 U11.23 142.55,17.95 142.37,17.76 142.08,17.76 141.34,18.5 141.34,21.72 143.02,23.4 143.02,27.76 143.13,27.87 U10.68
HDMI_TX2-: length 27.6
  TOP w0.095: U10.67 142.63,27.87 142.74,27.76 142.74,23.51 141.06,21.83 141.06,18.38 141.96,17.48 142.37,17.48 142.55,17.3 U11.22 144.37,17.3 144.55,17.48 145.53,17.48 151.52,11.5 151.52,9.71 151.42,9.61 151.25,9.61 151.16,9.52 J10.3
HDMI_VSYNC: length 70.3
  TOP w0.121: v1(146.37,74.31) 146.37,74.81 146.19,74.99 145.07,74.99 144.94,74.87 144.94,73.9 144.82,73.77 144.04,73.77 143.92,73.9 143.92,75.02 143.79,75.14 143.04,75.14 142.91,75.02 142.91,73.9 142.79,73.77 142.05,73.77 141.92,73.9 141.92,74.94 R305.1 ; v1(142.02,46.27) 141.26,46.27 141.07,46.46 138.44,46.46 138.31,46.33 138.31,44.61 138.19,44.49 137.65,44.49 137.53,44.61 137.53,46.33 137.4,46.46 136.86,46.46 136.74,46.34 136.74,44.86 136.62,44.74 136.38,44.74 136.26,44.86 136.26,46.34 136.14,46.46 135.89,46.46 135.77,46.34 135.77,44.86 135.65,44.74 135.41,44.74 135.29,44.86 135.29,46.34 135.17,46.46 134.54,46.46 134.41,46.33 134.41,44.99 133.07,43.65 133.07,41.51 135.26,39.33 136.71,39.33 137.13,38.92 U10.35
  BOTTOM w0.121: v1(142.02,46.27) 142.02,54.35 142.11,54.44 145.55,54.44 145.94,54.83 145.94,72.25 146.37,72.68 v1(146.37,74.31)
HDMICONN_CEC: length 12.1
  TOP w0.121: J10.13 146.16,9.87 145.45,10.58 144.61,10.58 144.49,10.7 142.91,10.7 142.02,11.59 141.64,11.59 138.54,14.7 U11.7
HDMICONN_HPLG: length 9.5
  TOP w0.121: U11.10 138.84,12.75 140.75,10.83 140.75,9.66 v1(142.2,8.22) 142.66,8.22 142.86,8.42 J10.19
  BOTTOM w0.121: R304.2 v1(142.2,8.22)
HDMICONN_I2CSCL: length 13.7
  TOP w0.121: v1(145.38,6.26) 145.16,6.48 J10.15 145.16,9.68 144.38,10.45 142.78,10.45 141.95,11.29 141.44,11.29 138.68,14.05 U11.8
  BOTTOM w0.121: v1(145.38,6.26) R276.1
HDMICONN_I2CSDA: length 13
  TOP w0.121: v1(144.66,6.23) J10.16 144.66,9.59 144.05,10.21 143.47,10.21 143.47,10.2 142.66,10.2 141.87,10.98 141.24,10.98 138.85,13.37 138.51,13.37 138.49,13.4 U11.9
  BOTTOM w0.121: R275.1 144.11,5.68 v1(144.66,6.23)
JTAG_DETECT: length 66
  TOP w0.121: U60.3 9.8,55.25 v1(9.56,55.49) ; J2.8 v1(31.41,93)
  LY3 w0.133: v1(9.56,55.49) 8.23,55.49 7.59,56.13 7.59,61.18 10.83,64.43 19.34,64.43 32.42,77.51 32.42,88.3 32.93,88.81 33.89,88.81 34.09,88.61 35.06,88.61 35.47,89.02 35.47,91.86 34.96,92.37 32.04,92.37 v1(31.41,93)
  BOTTOM w0.121: C380.1 R637.1 9.87,54.58 9.87,55.17 v1(9.56,55.49)
JTAG_EMU0: length 97.3
  TOP w0.102: v2(79.4,89) U2.C14
  TOP w0.121: v1(34.73,91.69) 35.17,91.69 35.37,91.5 47.08,91.5 48.45,92.86 56.14,92.86 57.23,93.95 59.28,93.95 59.91,93.32 60.94,93.32 62.14,94.53 63.83,94.53 64.67,93.69 65.46,93.69 65.96,93.18 66.14,93.18 66.31,93 67.75,93 68.52,92.23 69.98,92.23 70.3,92.55 v1(70.3,92.68) ; R582.1 v1(14.26,67.14) ; v1(22.14,89.19) J2.13
  LY3 w0.133: v1(14.26,67.14) 16.74,69.62 20.68,69.62 22.65,71.59 22.65,88.04 22.14,88.55 v1(22.14,89.19) 22.14,89.64 24.98,92.48 24.98,92.98 25.49,93.48 30.16,93.48 31.95,91.69 v1(34.73,91.69)
  BOTTOM w0.102: 78.98,89 v2(79.4,89)
  BOTTOM w0.121: 78.98,89 78.75,89.23 73.46,89.23 70.3,92.38 v1(70.3,92.68) ; R71.1 v1(22.14,89.19)
JTAG_EMU1: length 95.2
  TOP w0.102: 77.1,89.4 77.5,89 78.6,89 U2.B14
  TOP w0.121: J2.14 v1(31.41,89.19) ; v1(25.39,67.3) 18.13,67.3 18,67.17 v1(17.56,67.17) R583.1 ; 77.1,89.4 76.84,89.66 75.96,89.66 74.98,90.64 73.6,90.64 73.46,90.78 73.46,91.36 73.07,91.75 v1(73.06,91.75) ; v1(69.41,96.36) 69.1,96.68 65.75,96.68 65.33,96.26 63.08,96.26 62.36,95.53 60.23,95.53 59.45,94.75 57.31,94.75 55.92,93.36 48.11,93.36 47.14,92.38 33.35,92.38 32.88,92.85 32.88,93.46 32.57,93.76 v1(31.91,93.76)
  BOTTOM w0.121: v1(31.91,93.76) 31.91,89.7 v1(31.41,89.19) R70.1 30.39,85.71 26.28,81.6 26.28,68.19 v1(25.39,67.3) ; v1(69.41,96.36) 69.41,95.92 69.35,95.87 69.35,95.67 69.61,95.41 69.61,94.63 70.99,93.25 70.99,92.66 71.9,91.75 v1(73.06,91.75)
JTAG_TCK: length 100
  TOP w0.102: U2.A12 77.75,87 77.1,87.65
  TOP w0.121: v1(34.86,89.39) 35.3,89.39 35.5,89.6 47.32,89.6 49.03,91.31 54.69,91.31 56.26,89.75 59.1,89.75 59.85,89 v1(63.66,89) ; R576.1 v1(9.18,67.22) ; 77.1,87.65 76.33,88.42 75.37,88.42 74.62,89.17 74.4,89.39 74.36,89.39 69.49,89.39 69.49,89.4 69.26,89.4 67.94,90.72 65.63,90.72 65.51,90.84 v1(65.12,90.84)
  LY3 w0.133: v1(9.18,67.22) 11.04,65.37 19.42,65.37 24.68,70.62 24.68,89.19 v1(25.95,90.46) 30.44,90.46 31,89.9 34.35,89.9 v1(34.86,89.39)
  BOTTOM w0.121: v1(65.12,90.84) 65.12,90.14 63.98,89 v1(63.66,89) ; R74.2 R75.2 v1(25.95,90.46)
JTAG_TDI: length 112.6
  TOP w0.102: U2.B11 78.61,86.59 77.63,86.59 77.1,87.12
  TOP w0.121: v1(21.09,94.22) 21.41,94.53 21.41,94.58 22.36,95.54 J2.3 26.07,95.54 26.45,95.92 26.45,97.32 26.71,97.57 32.02,97.57 32.04,97.6 v1(34.15,97.6) ; R577.1 10.55,67.63 10.55,67.42 v1(10.15,67.02) ; v1(63.66,88.11) 59.41,88.11 58.81,88.71 56.38,88.71 54.4,90.69 49.29,90.69 47.57,88.98 40.44,88.98 39.32,87.86 34.22,87.86 v1(33.9,88.18) ; v1(71.02,87.84) 71.33,88.15 71.39,88.15 72.26,89.02 73.49,89.02 74.24,89.02 75.22,88.05 75.22,88.05 76.17,88.05 77.1,87.12
  LY3 w0.133: v1(10.15,67.02) 12,68.87 13.6,68.87 15.25,70.52 20.31,70.52 20.92,71.14 20.92,88.32 20.83,88.41 20.83,88.97 20.67,89.13 20.67,93.8 v1(21.09,94.22)
  BOTTOM w0.121: v1(71.02,87.84) 71.02,87.64 70.23,86.85 68.69,86.85 66.97,88.58 64.13,88.58 v1(63.66,88.11) ; v1(33.9,88.18) 33.9,88.67 33.84,88.73 33.84,97.29 v1(34.15,97.6)
JTAG_TDO: length 97.6
  TOP w0.102: U2.A11 77.45,86.2 77.1,86.55
  TOP w0.121: R578.1 11.21,67.37 v1(11.57,67.02) ; 77.1,86.55 75.98,87.67 75.07,87.67 74.09,88.64 74.05,88.64 72.52,88.64 72.37,88.5 71.27,87.4 70.76,87.4 70.58,87.58 70.58,88.26 69.69,89.15 69.16,89.15 67.85,90.45 65.64,90.45 65.27,90.08 65.14,90.08 65.14,90.08 64.03,90.08 63.39,90.72 61.63,90.72 61.56,90.65 56.92,90.65 55.52,92.05 48.72,92.05 47.01,90.34 35.42,90.34 35.2,90.56 v1(34.76,90.56) ; J2.7 v1(25.95,93)
  LY3 w0.133: v1(11.57,67.02) 12.46,67.02 12.8,66.67 14.45,66.67 15.35,67.57 15.58,67.57 17.37,69.36 20.79,69.36 22.91,71.48 22.91,89.96 v1(25.95,93) 30.06,93 32.5,90.56 v1(34.76,90.56)
JTAG_TMS: length 116.1
  TOP w0.102: U2.C11 79.41,86.59 v2(79.41,87.41)
  TOP w0.121: v1(69.25,99.92) 68.8,99.92 68.8,99.92 68.55,99.92 67.98,99.35 67.22,98.59 64.77,98.59 64.27,98.09 63.66,98.09 63.26,98.49 61.42,98.49 61.05,98.13 56.58,98.13 55.89,98.82 43.22,98.82 42.42,98.03 34.34,98.03 34.33,98.04 33.97,98.04 33.96,98.03 24.34,98.03 v1(24,97.69) J2.1 ; R579.1 12.23,67.27 13.65,65.85 v1(18.33,65.85)
  LY4 w0.121: v1(69.86,91.49) 69.89,91.49 70.9,92.5 70.9,93.58 68.87,95.6 68.87,99.1 69.25,99.47 v1(69.25,99.92)
  BOTTOM w0.102: 77.1,88.48 77.52,88.48 78.59,87.41 v2(79.41,87.41)
  BOTTOM w0.121: v1(69.86,91.49) 69.86,91.25 71.28,89.83 71.81,89.83 73.15,88.48 77.1,88.48 ; v1(24,97.69) 22.63,97.69 19.77,94.83 19.77,92.32 19.39,91.93 19.39,90.31 19.52,90.19 19.52,83.32 22.57,80.28 22.57,69.33 19.09,65.85 v1(18.33,65.85)
JTAG_TRSTN: length 108
  TOP w0.102: 77.1,86.17 77.44,85.83 78.4,85.83 78.82,85.4 U2.B10
  TOP w0.121: v1(34.28,96.81) 32.67,96.81 32.66,96.82 32.29,96.82 32.28,96.81 v1(31.41,96.81) J2.2 ; v1(64.71,89.02) 64.3,89.02 63.85,88.56 63.48,88.56 63.48,88.56 59.53,88.56 58.65,89.45 56.18,89.45 54.56,91.06 49.13,91.06 47.42,89.35 40.24,89.35 39.63,88.74 34.59,88.74 v1(34.28,89.05) ; 77.1,86.17 75.86,87.41 74.97,87.41 73.98,88.4 73.95,88.4 72.62,88.4 71.37,87.15 70.66,87.15 70.51,87.3 70.14,87.67 v1(70.14,87.87) ; R580.1 v1(13.25,67.12)
  LY3 w0.133: v1(13.25,67.12) 13.25,67.61 15.52,69.88 20.57,69.88 21.57,70.87 21.57,75.17 21.4,75.33 21.4,75.7 21.57,75.87 21.57,92.1 21.8,92.34 21.8,93.31 24.42,95.92 30.52,95.92 v1(31.41,96.81)
  BOTTOM w0.121: v1(31.41,96.81) R79.2 ; v1(64.71,89.02) 67.78,89.02 68.92,87.87 70.13,87.87 v1(70.14,87.87) ; v1(34.28,96.81) 34.28,96.37 34.28,96.37 34.28,89.5 34.28,89.5 v1(34.28,89.05)
LCD_DATA0: length 4.5
  TOP w0.102: 138.01,85.25 J7.4
  TOP w0.121: 138.01,85.25 138.54,85.79 138.95,85.79 139.1,85.94 139.1,86.07 138.88,86.29 138.88,86.34 139.07,86.52 140.02,86.52 140.12,86.42 140.12,86.27 R240.1
LCD_DATA1: length 4.7
  TOP w0.102: 138.04,85.91 136.59,85.91 J7.3
  TOP w0.121: R241.1 139.23,87.03 138.11,85.91 138.04,85.91
LCD_DATA2: length 4.4
  TOP w0.102: J7.6 137.91,83.98 138.04,83.86
  TOP w0.121: R245.1 140.14,83.88 140.14,83.98 140.01,84.11 139.65,84.11 139.63,84.14 139.43,84.14 139.25,83.96 139.25,83.68 139.17,83.6 138.98,83.6 138.85,83.72 138.85,83.83 138.78,83.9 138.61,83.9 138.52,83.81 138.52,83.73 138.39,83.6 138.39,83.6 138.24,83.6 138.06,83.78 138.06,83.83 138.04,83.86
LCD_DATA3: length 4.5
  TOP w0.121: R246.1 139.61,84.87 139.1,84.87 v1(138.72,84.49)
  BOTTOM w0.102: 138.04,84.49 137.93,84.59 136.54,84.59 J7.5
  BOTTOM w0.121: v1(138.72,84.49) 138.04,84.49
LCD_DATA4: length 4.5
  TOP w0.102: J7.8 137.83,82.71 137.98,82.56 137.98,82.21 138.04,82.16
  TOP w0.121: 138.04,82.16 138.18,82.01 138.3,82.01 138.44,82.16 138.63,82.16 138.86,81.93 139,81.93 139.1,82.03 139.1,82.21 139.18,82.28 139.33,82.28 139.53,82.08 140.07,82.08 140.13,82.01 140.13,81.84 R251.1
LCD_DATA5: length 4.5
  TOP w0.121: v1(138.59,82.84) 138.85,82.59 R252.1
  BOTTOM w0.102: J7.7 136.56,83.35 137.96,83.35 138.04,83.27
  BOTTOM w0.121: 138.04,83.27 138.47,82.84 v1(138.59,82.84)
LCD_DATA6: length 4.5
  TOP w0.102: J8.15 130.67,77.63 130.52,77.79 130.52,78.32
  TOP w0.121: R270.1 129.15,77.76 129.27,77.63 129.27,77.53 129.4,77.41 129.93,77.41 130.06,77.53 130.06,78.32 130.19,78.45 130.39,78.45 130.52,78.32
LCD_DATA7: length 8.6
  TOP w0.121: v1(129.49,82.55) 129.2,82.84 R259.1
  LY3 w0.102: 130.57,81.44 J8.9
  LY3 w0.133: 130.57,81.44 130.21,81.44 130.09,81.57 130.09,83.2 129.96,83.32 127.88,83.32 127.75,83.2 127.75,82.9 128.1,82.55 v1(129.49,82.55)
LCD_DATA8: length 9.4
  TOP w0.102: 133.59,80.94 133.49,80.83 132.19,80.83 131.53,80.17 J8.11 ; 130.72,82.08 133.46,82.08 133.59,81.95
  TOP w0.121: 133.59,80.94 133.64,80.94 133.84,81.14 133.84,81.83 133.72,81.95 133.59,81.95 ; R262.1 129.53,80.81 130.14,81.42 130.14,81.78 130.26,81.9 130.26,81.9 130.44,82.08 130.72,82.08
LCD_DATA9: length 4.1
  TOP w0.102: R266.1 129.2,78.78 129.31,78.68 129.31,78.14 129.41,78.04 129.61,78.04 129.71,78.14 129.71,78.68 129.81,78.78 130.54,78.78 130.67,78.9 J8.13
LCD_DATA10: length 10.1
  TOP w0.121: v1(138.72,80.37) 139.18,79.91 139.18,79.67 139.31,79.54 R256.1
  LY3 w0.102: J7.10 138.01,81.44 138.14,81.32
  LY3 w0.133: 138.14,81.32 138.47,80.99 139.99,80.99 140.09,80.89 140.09,78.68 139.97,78.55 138.85,78.55 138.72,78.68 v1(138.72,80.37)
LCD_DATA11: length 10.7
  TOP w0.121: v1(138.89,77.34) 139.1,77.13 R267.1
  LY3 w0.102: 141.67,77.91 138.29,77.91 138.01,77.63 J7.16
  LY3 w0.133: 141.67,77.91 141.79,77.79 141.79,76.62 141.67,76.49 139.13,76.49 138.89,76.73 v1(138.89,77.34)
LCD_DATA12: length 13.1
  TOP w0.121: R257.1 139.86,80.94 139.74,81.07 138.46,81.07 138.34,81.19 138.34,81.32 v1(138.59,81.57)
  BOTTOM w0.102: 138.04,82.42 137.97,82.42 137.63,82.08 136.56,82.08 J7.9
  BOTTOM w0.121: 138.04,82.42 138.09,82.42 138.21,82.3 138.21,82.16 138.29,82.08 139.05,82.08 139.18,82.21 139.18,84.62 139.27,84.72 139.41,84.72 139.51,84.62 139.51,81.77 139.31,81.57 v1(138.59,81.57)
LCD_DATA13: length 18.6
  TOP w0.121: R258.1 129.27,81.83 v1(129.53,81.57)
  LY3 w0.102: J8.10 133.59,81.44 ; 133.59,80.83 130.99,80.83 130.72,80.57
  LY3 w0.133: 133.59,80.83 134.38,80.83 134.5,80.96 134.5,81.25 134.38,81.38 134.2,81.38 134.07,81.51 134.07,81.79 134.2,81.91 134.43,81.91 134.56,82.04 134.56,82.32 134.43,82.45 134.28,82.45 134.15,82.57 134.15,82.85 134.28,82.98 134.4,82.98 134.53,83.11 134.53,83.93 134.4,84.06 134.23,84.06 134.08,84.21 134.08,84.45 133.96,84.57 133.79,84.57 133.67,84.45 133.67,81.52 133.59,81.44 ; 130.72,80.57 130.4,80.57 130.26,80.7 130.26,80.83 130.13,80.97 129.37,80.97 128.41,81.93 128.41,82.02 128.54,82.16 128.94,82.16 v1(129.53,81.57)
LCD_DATA14: length 9.2
  TOP w0.102: 138.04,80.17 J7.12 ; 138.04,78.87 138.04,78.88 138.04,79.72
  TOP w0.121: 138.04,79.72 138.16,79.84 138.16,80.05 138.04,80.17 ; R260.1 140.25,78.78 140.25,78.85 140.06,79.03 139.65,79.03 139.57,79.12 139.4,79.12 139.25,78.97 139.25,78.35 139.14,78.24 138.98,78.24 138.87,78.35 138.87,79.72 138.75,79.84 138.57,79.84 138.44,79.72 138.44,78.44 138.33,78.32 138.16,78.32 138.04,78.44 138.04,78.87
LCD_DATA15: length 24.4
  TOP w0.121: R254.1 v1(129.7,83.86)
  LY3 w0.102: J8.7 130.65,82.71 130.55,82.82
  LY3 w0.133: v1(129.7,83.86) 127.14,83.86 127.01,83.98 127.01,85.41 127.14,85.55 129.82,85.55 129.96,85.68 129.96,85.95 129.82,86.08 127.14,86.08 127.01,86.21 127.01,86.47 127.14,86.6 127.4,86.6 127.65,86.85 127.93,86.85 128.19,86.6 130.29,86.6 130.42,86.47 130.42,85.29 130.28,85.15 128.29,85.15 128.15,85.02 128.15,84.75 128.29,84.62 130.28,84.62 130.42,84.49 130.42,82.95 130.55,82.82
LCD_DATA16: length 64.1
  TOP w0.121: v1(116.34,98.16) 115.89,98.16 115.77,98.28 115.77,98.6 115.89,98.72 119.3,98.72 119.42,98.84 119.42,99.08 119.3,99.2 115.89,99.2 115.77,99.32 115.77,99.49 115.65,99.61 115.41,99.61 115.29,99.49 115.29,98.28 115.17,98.16 114.03,98.16 113.7,97.82 104.99,97.82 103.21,96.04 100.06,96.04 98.64,94.62 98.64,93.69 98.36,93.41 97.53,93.41 R253.1
  LY4 w0.133: v1(116.34,98.16) 116.47,98.03 116.47,96.42 116.34,96.28 115.79,96.28 115.66,96.15 115.66,95.88 115.79,95.75 116.34,95.75 116.47,95.62 116.47,94.75 116.79,94.43 116.79,93.86 116.78,93.84 116.78,87.18 117,86.96 v1(117,86.38)
  BOTTOM w0.102: 130.72,82.16 130.77,82.1 132.09,82.1 132.7,82.71 J8.8
  BOTTOM w0.121: v1(117,86.38) 117.26,86.63 126.85,86.63 127.14,86.35 127.14,84.34 127.7,83.78 129.1,83.78 130.72,82.16
LCD_DATA17: length 46.1
  TOP w0.121: R248.1 103.27,94.27 104.79,95.79 117.25,95.79 117.54,96.07 v1(118.41,96.07)
  LY4 w0.133: v1(118.02,87.46) 118.02,89.56 118.41,89.95 118.41,93.51 118.54,93.64 119.54,93.64 119.67,93.78 119.67,94.04 119.54,94.18 118.54,94.18 118.41,94.31 118.41,94.58 118.54,94.71 119.54,94.71 119.67,94.84 119.67,95.11 119.54,95.24 118.54,95.24 118.41,95.38 v1(118.41,96.07)
  BOTTOM w0.102: J8.5 131.28,83.98 130.72,84.54 130.72,84.75
  BOTTOM w0.121: v1(118.02,87.46) 118.97,87.46 119.16,87.28 119.52,87.28 119.71,87.46 127.7,87.46 130.03,85.13 130.34,85.13 130.72,84.75
LCD_DATA18: length 53.5
  TOP w0.102: 130.72,83.48 130.85,83.35 132.12,83.35 J8.6
  TOP w0.121: 130.72,83.48 129.75,84.45 128.48,84.45 127.67,85.25 127.67,85.57 127.55,85.69 126.17,85.69 126.05,85.81 126.05,86.06 126.17,86.18 127.55,86.18 127.67,86.3 127.67,87.03 127.55,87.16 126,87.16 125.24,86.4 125.24,86.23 125.57,85.89 125.57,85.72 125.4,85.55 125.23,85.55 124.9,85.89 124.72,85.89 124.55,85.72 124.55,85.55 124.89,85.21 124.89,85.04 124.72,84.87 124.55,84.87 124.21,85.21 124.04,85.21 123.87,85.03 123.87,84.86 124.21,84.53 124.21,84.36 124.04,84.19 123.87,84.19 123.53,84.52 123.36,84.52 123.19,84.35 123.19,84.18 123.53,83.84 123.53,83.67 123.36,83.5 123.19,83.5 122.85,83.84 122.68,83.84 122.4,83.56 114.37,83.56 112.77,81.96 109.55,81.96 108.11,83.4 108.11,85.93 106.78,87.26 v1(106.78,88.24) ; R247.1 97.51,88.86 97.52,88.87 97.9,88.87 98,88.78 98.79,88.78 98.92,88.9 v1(98.92,89.04)
  BOTTOM w0.121: v1(98.92,89.04) 104.91,89.04 105.71,88.24 106.77,88.24 v1(106.78,88.24)
LCD_DATA19: length 30.1
  TOP w0.121: R264.1 112.41,86.12 115,86.12 115.18,85.94 116.82,85.94 116.82,85.94 117.19,85.94 117.19,85.94 117.68,85.94 118.33,85.29 v1(118.77,85.29)
  LY3 w0.102: J7.13 133.82,78.9 133.16,79.56 131.03,79.56 130.63,79.96
  LY3 w0.133: 130.63,79.96 129.88,80.71 129.09,80.71 126.55,83.25 126.55,85.91 125.34,87.13 122.06,87.13 120.22,85.29 v1(118.77,85.29)
LCD_DATA20: length 26.6
  TOP w0.102: 130.72,85.25 J8.3
  TOP w0.121: R243.1 112.48,82.71 112.84,83.07 112.84,83.36 112.72,83.48 112.48,83.48 112.36,83.6 112.36,83.93 112.48,84.05 122.19,84.05 125.8,87.67 127.93,87.67 128.18,87.41 128.18,85.52 128.75,84.95 130.28,84.95 130.59,85.25 130.72,85.25
LCD_DATA21: length 35.6
  TOP w0.102: 130.72,85.89 132.12,85.89 J8.4
  TOP w0.121: 130.72,85.89 130.02,85.19 128.96,85.19 128.43,85.73 128.43,87.52 128.31,87.64 128.31,87.67 128.06,87.92 125.7,87.92 122.09,84.3 114.34,84.3 113.96,84.69 113.96,84.9 114.08,85.03 117.21,85.03 117.33,85.15 117.33,85.57 117.21,85.69 116.72,85.69 116.72,85.69 112.74,85.69 112.3,85.26 111.84,85.26 111.34,85.76 R242.1
LCD_DATA22: length 52.5
  TOP w0.121: R263.1 v1(104.81,91.6)
  LY3 w0.133: v1(137.36,91.12) 139.08,91.12 139.56,90.63 139.56,90.28 139.83,90.01 139.85,90.01 139.85,89.96 v1(140.17,89.65)
  BOTTOM w0.102: 138.04,78.9 J7.14
  BOTTOM w0.121: v1(137.36,91.12) 136.97,91.12 136.18,90.33 132.49,90.33 131.9,90.92 131.86,90.92 131.07,91.71 130.05,91.71 129.12,90.77 128.68,90.33 125.3,90.33 124.97,90.66 112.1,90.66 111.85,90.91 108.62,90.91 107.92,91.6 v1(104.81,91.6) ; v1(140.17,89.65) 140.48,89.34 140.48,89.22 140.8,88.91 140.8,80.7 139,78.9 138.04,78.9
LCD_DATA23: length 44.4
  TOP w0.121: R261.1 108.77,91.6 110.3,93.13 114.92,93.13 115.05,93 118.12,93 118.53,93.41 v1(119.98,93.41) ; v1(128.89,87.59) 128.13,88.35 128.13,88.48 128.01,88.6 120.22,88.6 v1(119.34,87.72)
  LY3 w0.102: v1(128.89,87.59) 129.6,87.59 129.64,87.63 129.74,87.63 129.78,87.67 130.14,87.67 130.21,87.59 130.54,87.59 130.72,87.41 133.92,87.41 134.81,86.52 134.81,85.36 135.04,85.13 135.04,80.25 135.11,80.17 J7.11
  LY4 w0.133: v1(119.98,93.41) 119.34,92.77 v1(119.34,87.72)
LCD_DEN: length 20.6
  TOP w0.102: v1(130.01,76.36) 129.32,76.36 R273.1
  BOTTOM w0.102: J8.17 130.72,76.36 ; 133.59,77.33 133.59,77.36 133.72,77.48 133.72,77.99 ; 130.72,75.71 133.44,75.71 133.57,75.58 133.57,75.14 ; 133.59,77.05 133.53,76.99 130.73,76.99 130.72,77
  BOTTOM w0.121: 133.57,75.14 133.7,75.02 134.08,75.02 134.25,75.19 134.25,77.99 134.12,78.12 133.84,78.12 133.72,77.99 ; 130.72,77 130.64,77 130.52,77.12 130.52,79.16 130.39,79.29 130.14,79.29 130.01,79.16 v1(130.01,76.36) ; 130.72,75.71 130.54,75.71 130.42,75.84 130.42,76.24 130.54,76.36 130.72,76.36 ; 133.59,77.33 133.59,77.05
LCD_HSYNC: length 6
  TOP w0.102: 130.72,75.7 132.09,75.7 J8.18
  TOP w0.121: R272.1 129.3,74.71 129.55,74.46 130.16,74.46 130.29,74.58 130.29,74.93 130.16,75.06 130.09,75.06 129.96,75.18 129.96,75.41 130.09,75.54 130.45,75.54 130.62,75.7 130.72,75.7
LCD_I2C_SCL: length 19.6
  TOP w0.102: 133.59,78.07 J8.14
  TOP w0.121: 146.85,71.79 146.85,72.55 146.09,73.32 140.06,73.32 139.01,74.37 138.44,74.37 138.29,74.23 135.95,74.23 134,74.23 133.59,74.64 133.59,78.07
LCD_I2C_SDA: length 17.1
  TOP w0.102: 138.34,77 136.56,77 J7.15
  TOP w0.121: 146.85,70.52 147.35,71.03 147.35,73.55 147.23,73.67 147.23,74.87 146.44,75.65 142.99,75.65 142.02,76.62 138.72,76.62 138.34,77
LCD_PCLK: length 4.4
  TOP w0.102: 130.72,77 131.99,77 132.63,77.63 J8.16
  TOP w0.121: 130.72,77 128.94,77 R269.1
LCD_VSYNC: length 4.5
  TOP w0.102: J7.17 136.59,75.7 138.04,75.7
  TOP w0.121: R271.1 138.77,74.97 138.04,75.7
LCDA_PIN18: length 2.8
  TOP w0.102: 138.04,76.36 J7.18
  TOP w0.121: R274.2 138.85,75.98 138.47,76.36 138.04,76.36
MCASP0_ACLKR: length 27
  TOP w0.121: R218.1 v1(70.62,107.48)
  BOTTOM w0.121: J6.17 67.22,120.35 67.21,120.34 67.26,120.34 70.82,116.79 70.82,108.32 70.62,108.13 v1(70.62,107.48)
MCASP0_ACLKX: length 7.1
  TOP w0.121: R194.2 87.54,131.53 v1(87.84,131.23)
  BOTTOM w0.121: v1(87.84,131.23) 88.49,130.58 88.49,126.59 J6.1
MCASP0_AHCLKR: length 45.2
  TOP w0.121: R211.2 82.21,155.61 81.68,155.09 71.02,155.09 v1(70.52,155.59)
  BOTTOM w0.121: J6.13 72.3,126.68 71.2,127.78 71.2,135.19 70,136.4 70,140.46 70.16,140.63 70.16,147.87 69.89,148.14 69.89,151.55 70.16,151.82 70.16,155.23 v1(70.52,155.59)
MCASP0_AHCLKX: length 20.9
  TOP w0.121: J6.27 v1(45.5,125.64) ; R234.1 v1(45.17,114.59)
  BOTTOM w0.121: v1(45.17,114.59) 45.17,119.42 45.5,119.75 v1(45.5,125.64)
MCASP0_AXR0: length 1.8
  BOTTOM w0.121: R203.2 J6.7
MCASP0_AXR1: length 8.4
  TOP w0.121: R227.1 52.48,126.66 57.43,126.66 58.46,125.64 J6.23
MCASP0_FSR: length 31.2
  TOP w0.121: R224.1 73.7,102.78 v1(73.44,103.03) ; J6.21 62.97,124.81 63.83,124.81 64.78,123.86 v1(68.36,123.86)
  BOTTOM w0.121: v1(73.44,103.03) 73.44,104.38 72.86,104.96 72.86,119.18 70.27,121.77 69.57,121.77 68.79,122.54 68.79,123.43 v1(68.36,123.86)
MCASP0_FSX: length 1.8
  BOTTOM w0.121: R199.2 J6.5
MMC2_CLK: length 39.9
  TOP w0.121: U28.13 21.76,106.66 4.89,106.66 4.61,106.94 4.61,107.33 4.74,107.45 7.64,107.45 7.76,107.58 7.76,107.99 7.64,108.11 v1(4.61,108.11)
  BOTTOM w0.121: R485.1 5.12,111.16 4.74,110.78 4.1,110.78 3.85,110.53 3.85,106.72 3.97,106.59 7.81,106.59 7.94,106.72 7.94,107.2 7.81,107.33 5.8,107.33 5.68,107.45 5.68,108.42 5.55,108.55 4.74,108.55 4.61,108.42 v1(4.61,108.11)
MMC2_CMD: length 40.1
  TOP w0.121: U28.12 20.44,107.37 19.98,106.91 17.87,106.91 17.74,107.04 17.74,107.83 17.61,107.96 13.63,107.96 13.5,107.83 13.5,107.56 13.63,107.43 16.8,107.43 16.93,107.3 16.93,107.04 16.8,106.91 8.14,106.91 8.01,107.04 8.01,109 7.89,109.13 4.74,109.13 4.62,109 4.62,108.88 4.49,108.75 3.85,108.75 3.59,109 3.59,109.51 2.83,110.27 2.83,115.43 2.96,115.56 3.62,115.56 3.75,115.43 3.75,113.58 3.87,113.45 v1(4.36,113.45)
  BOTTOM w0.121: R486.1 v1(4.36,113.45)
MMC2_D0: length 40.6
  TOP w0.121: v1(4.36,116.88) 4.04,116.88 3.91,116.75 3.91,116.12 3.79,115.99 3.49,115.99 3.36,116.12 3.36,119.26 3.24,119.39 2.7,119.39 2.58,119.26 2.58,108.62 4.78,106.42 19.74,106.42 20.81,105.35 21.98,105.35 22.27,105.64 U28.14
  BOTTOM w0.121: R487.1 5.12,115.73 4.99,115.86 4.99,116.24 v1(4.36,116.88)
MMC2_D1: length 39.8
  TOP w0.121: v1(4.48,119.16) 4.48,118.53 4.36,118.4 3.8,118.4 3.67,118.53 3.67,119.7 3.54,119.82 2.45,119.82 2.32,119.7 2.32,108.5 4.65,106.17 19.45,106.17 20.55,105.07 22.52,105.07 22.77,105.32 U28.15
  BOTTOM w0.121: R488.1 v1(4.48,119.16)
MMC2_D2: length 39.5
  TOP w0.121: U28.8 20.47,109.37 19.87,109.97 v1(19.26,109.97) ; v1(18.63,105.7) 18.41,105.92 4.52,105.92 2.07,108.37 2.07,119.9 2.48,120.31 v1(4.48,120.31)
  BOTTOM w0.121: v1(19.26,109.97) 19.26,108.85 18.63,108.22 v1(18.63,105.7) ; R489.1 v1(4.48,120.31)
MMC2_D3: length 40.5
  TOP w0.121: v1(19.34,107.86) 19.85,108.37 U28.10 ; v1(4.36,123.1) 1.82,120.56 1.82,108.24 4.38,105.67 17.99,105.67 18.41,105.26 18.98,105.26 19.34,105.62 v1(19.34,105.65)
  BOTTOM w0.121: v1(4.36,123.1) 5.12,123.1 R490.1 ; v1(19.34,107.86) v1(19.34,105.65)
MMC2_SDIO_SEL: length 3.4
  TOP w0.121: R515.1 R516.2 26.31,109.87 U28.24
MMC_CD: length 71.8
  TOP w0.121: R380.1 72.3,91.15 71.79,90.64 70.36,90.64 69.97,91.03 69.02,91.03 67.75,92.3 66.55,92.3 v1(66.55,92.3) ; v1(62.27,144.18) R378.1 64.14,144.18 U21.3 64.28,144.08 64.63,144.08 64.76,144.21 64.76,145.99 64.3,146.44 J13.15
  BOTTOM w0.121: v1(62.27,144.18) 63.28,144.18 64.43,143.04 64.43,138.98 63.92,138.47 63.16,138.47 62.46,137.77 62.46,136.68 62.52,136.62 62.52,135.55 60.94,133.97 60.94,123.03 66.21,117.76 66.21,105.92 66.91,105.22 66.91,102.36 66.5,101.95 66.5,99.38 66.39,99.28 66.39,92.94 66.56,92.77 66.56,92.31 v1(66.55,92.3)
MMC_CLK: length 42.1
  TOP w0.121: J13.20 53.03,149.78 53.15,149.9 56.18,149.9 56.3,149.78 56.3,148.58 J13.5 56.37,143.72 56.68,143.42 U19.1 57.71,142.94 57.57,142.8 57.57,141.92 57.7,141.79 60.29,141.79 61.07,142.58 65.23,142.58 66.54,143.89 72.68,143.89 72.88,143.68 77.61,143.68 77.82,143.89 81.3,143.89 81.8,144.39 81.81,144.39 82.36,144.94 83.21,144.94 v1(83.53,145.25)
  BOTTOM w0.121: R398.1 83.6,145.17 v1(83.53,145.25)
MMC_CMD: length 51.3
  TOP w0.121: U19.7 58.71,145.32 v1(58.97,145.58) ; v1(55.41,150.85) 55.34,150.79 49.6,150.79 48.88,150.06 J13.2 48.73,148.35 48.73,147.28 v1(48.55,147.1) ; J13.17 v1(59.73,147.11)
  LY3 w0.133: v1(58.97,145.58) 59.55,145.58 59.65,145.68 62.8,145.68 62.97,145.51 64.08,145.51 64.76,146.19 73.95,146.19 74.59,145.55 v1(80.78,145.55)
  BOTTOM w0.121: v1(80.78,145.55) 81.19,145.15 R397.1 ; v1(58.97,145.58) 58.97,146.35 v1(59.73,147.11) J13.17 59.85,148.63 61.51,148.63 61.63,148.75 61.63,150.91 61.51,151.04 60.36,151.04 59.48,150.16 56.93,150.16 56.81,150.28 56.81,150.53 56.68,150.66 55.54,150.66 55.41,150.79 v1(55.41,150.85) ; R366.1 v1(48.55,147.1)
MMC_D0: length 47.7
  TOP w0.121: v1(61.38,147.1) 61.38,148.42 J13.7 61.12,148.68 61.12,149.77 61,149.9 56.67,149.9 56.43,150.14 50.96,150.14 50.53,149.71 J13.22 50.68,148.34 50.68,147.26 v1(50.84,147.1) ; v1(77.99,145.1) 77.99,144.41 77.51,143.93 72.99,143.93 72.78,144.13 66.44,144.13 65.14,142.84 60.77,142.84 60.03,142.1 58.44,142.1 v1(58.01,142.53) 58.01,142.84 58.13,142.96 58.13,143.34 U19.2
  BOTTOM w0.121: R399.1 78.02,145.1 v1(77.99,145.1) ; v1(61.38,147.1) 61.38,146.57 60.95,146.14 60.69,146.14 59.37,144.82 58.58,144.82 58.32,144.55 58.32,142.84 v1(58.01,142.53) ; v1(50.84,147.1) R367.1
MMC_D1: length 42.2
  TOP w0.121: U19.3 58.71,142.66 v1(58.8,142.57) 58.94,142.43 59.88,142.43 60.31,142.86 60.31,143.63 61.89,145.21 61.89,145.83 63,146.95 J13.8 63,150.02 62.87,150.15 56.81,150.15 56.56,150.39 50.1,150.39 49.72,150.01 J13.23 49.69,148.47 v1(49.69,147.1)
  LY3 w0.133: v1(58.8,142.57) 65.35,142.57 66.68,143.89 69.73,143.89 v1(71.03,145.2)
  BOTTOM w0.121: R368.1 v1(49.69,147.1) ; R400.1 v1(71.03,145.2)
MMC_D2: length 42.7
  TOP w0.121: U19.6 59.98,144.69 v1(60.18,144.89) 62.15,146.86 v1(62.15,147.1) J13.24 ; v1(43.85,147.1) 43.85,148.48 J13.9 43.88,149.79 44.42,150.34 46.45,150.34 47.66,151.54 57.7,151.54 v1(58.33,150.91)
  LY3 w0.133: v1(60.18,144.89) 62.55,144.89 63.3,144.14 66.44,144.14 66.51,144.21 67.18,144.21 v1(68.19,145.22)
  BOTTOM w0.121: v1(62.15,147.1) 62.15,151.28 61.51,151.93 59.35,151.93 v1(58.33,150.91) ; R369.1 v1(43.85,147.1) ; R401.1 68.49,144.91 68.19,145.2 v1(68.19,145.22)
MMC_D3: length 41.8
  TOP w0.121: v1(46.38,147.12) J13.1 46.45,148.58 46.45,149.83 47.92,151.29 57.06,151.29 v1(57.44,150.91) ; J13.16 v1(60.52,147.13) 60.52,146.69 60.17,146.34 58.58,146.34 58.21,145.96 v1(58.21,145.45) U19.8
  LY3 w0.133: v1(66.97,145.2) 66.1,145.2 65.42,144.51 63.44,144.51 62.61,145.34 60,145.34 59.79,145.13 58.78,145.13 58.52,145.13 v1(58.21,145.45)
  BOTTOM w0.121: R396.1 v1(66.97,145.2) ; v1(46.38,147.12) 46.38,147.85 R365.1 ; v1(57.44,150.91) 57.44,150.78 57.82,150.4 59.34,150.4 59.6,150.66 59.6,151.42 59.85,151.68 61.25,151.68 61.89,151.04 61.89,148.5 v1(60.52,147.13)
MMC_D4: length 49.4
  TOP w0.121: U20.1 72.71,148.87 72.71,148.6 v1(72.94,148.37) ; v1(47.6,164.25) J13.10 47.6,167.62 48.3,168.31 63.54,168.31 64.81,167.04 64.81,163.61 65.19,163.23 v1(72.17,163.23)
  BOTTOM w0.121: R370.1 47.6,165.2 v1(47.6,164.25) ; v1(72.17,163.23) 72.17,152.95 72.55,152.56 72.55,148.75 v1(72.94,148.37)
MMC_D5: length 45.6
  TOP w0.121: v1(73.06,162.72) 64.93,162.72 64.3,163.36 64.3,166.79 63.16,167.93 50.58,167.93 50.1,167.45 J13.11 50.12,165.48 v1(50.12,164.25) ; U20.2 v1(73.32,149.52)
  BOTTOM w0.121: v1(73.06,162.72) 73.06,150.53 73.32,150.28 v1(73.32,149.52) ; v1(50.12,164.25) 50.12,165.21 R371.1
MMC_D6: length 34.4
  TOP w0.121: v1(57.6,164.31) J13.12 57.6,166.44 57.57,166.47 57.57,166.79 57.95,167.17 62.52,167.17 63.28,166.41 63.28,162.85 63.98,162.15 v1(71.16,162.15) ; U20.7 70.65,150.02 v1(70.52,150.15)
  BOTTOM w0.121: v1(57.6,164.31) 57.6,165.23 R372.1 ; v1(70.52,150.15) 70.52,154.34 71.16,154.98 v1(71.16,162.15)
MMC_D7: length 32
  TOP w0.121: U20.8 70.65,149.52 v1(70.52,149.39) ; v1(60.11,164.38) 60.11,165.49 J13.13 60.1,166.44 60.2,166.53 62.39,166.53 62.9,166.03 62.9,162.72 63.92,161.71 69.89,161.71 70.14,161.45 v1(71.67,161.45)
  BOTTOM w0.121: v1(71.67,161.45) 71.67,154.72 70.96,154.02 70.96,149.83 v1(70.52,149.39) ; R373.1 v1(60.11,164.38)
MMC_WP: length 58.1
  TOP w0.121: R379.1 76.02,106.46 75.77,106.71 70.77,106.71 70.01,105.96 v1(67.22,105.96) ; J13.14 v1(65.5,145.58) 65.5,145.17 U21.5
  BOTTOM w0.121: v1(65.5,145.58) 64.67,144.75 64.67,136.63 61.89,133.85 61.89,129.84 61.24,129.19 61.24,128.63 61.19,128.57 61.19,127.79 62.39,126.59 62.53,126.59 63.09,126.03 63.09,125.25 62.39,124.55 62.39,122.59 63.43,121.55 63.48,121.55 66.71,118.33 66.71,106.47 v1(67.22,105.96)
MVRK_GPIO1_D0: length 6.4
  TOP w0.121: J16.2 114.34,161.07 R437.1
MVRK_GPIO1_D1: length 75.9
  TOP w0.121: v1(104.94,155.1) 104.94,155.31 104.05,156.2 104.05,163.61 104.3,163.87 109,163.87 J16.4
  LY4 w0.133: v1(104.94,155.1) 105.59,154.45 105.59,123.86 104.25,122.52 104.25,119.85 104.56,119.54 104.56,114.92 102.27,112.64 v1(102.27,110.08)
  BOTTOM w0.121: v1(102.27,110.08) 103.21,109.14 103.21,101.71 103.75,101.18 103.75,98.02 103.87,97.89 R439.1
MVRK_GPIO1_D2: length 72.8
  TOP w0.121: v1(104.94,154.34) 105.57,154.98 105.57,155.99 104.43,157.13 104.43,163.24 104.81,163.61 107.61,163.61 107.86,163.36 J16.6
  LY4 w0.133: v1(101.45,110.08) 101.45,115.57 101.8,115.92 101.8,121.08 105.14,124.42 105.14,154.14 v1(104.94,154.34)
  BOTTOM w0.121: v1(101.45,110.08) 102.47,109.06 102.47,99.03 102.78,98.72 R440.1
MVRK_GPIO1_D3: length 67.4
  TOP w0.121: J16.8 106.24,161.55 106.24,154.31 v1(106.21,154.28)
  LY4 w0.133: v1(106.21,154.28) 105.85,153.92 105.85,123.46 104.59,122.19 104.59,120.05 104.89,119.75 104.89,114.36 103.1,112.57 v1(103.1,110.08)
  BOTTOM w0.121: R441.1 105.32,99.36 105.23,99.45 105.23,100.27 103.86,101.64 103.86,103.53 103.54,103.85 103.54,109.64 v1(103.1,110.08)
MVRK_GPIO1_D4: length 6.6
  TOP w0.121: J16.10 101.89,161.58 101.89,158.56 102.91,157.54 R442.1
MVRK_GPIO1_D5: length 6.4
  TOP w0.121: J16.12 101.13,161.58 101.13,158.43 100.37,157.67 R444.1
MVRK_GPIO1_D6: length 6.5
  TOP w0.121: R446.1 97.45,157.82 96.66,158.61 96.66,161.43 J16.14
MVRK_GPIO1_D7: length 6.1
  TOP w0.121: R447.1 94.27,156.76 94.27,161.58 J16.16
MVRK_GPIO1_LATCHEN: length 6.5
  TOP w0.121: J16.20 89.17,161.56 89.17,157.97 90.08,157.06 R450.1
MVRK_I2C_SCL: length 93.2
  TOP w0.121: v1(73.57,159.83) 75.14,159.83 79.44,164.12 98.64,164.12 99.35,163.41 99.35,160.82 J16.11 ; v1(75.66,102.27) 76.24,101.7 R443.2
  BOTTOM w0.121: v1(75.66,102.27) 75.82,102.43 75.82,103.07 75.66,103.23 75.66,119.81 75.05,120.43 75.05,120.52 73.25,122.32 73.25,122.53 73.25,128.75 71.45,130.55 71.45,135.63 71.98,136.16 71.98,139.96 73.58,141.56 73.58,148.75 73.76,148.93 73.76,150.36 73.58,150.53 73.58,155.45 73.57,155.46 v1(73.57,159.83)
MVRK_I2C_SDA: length 91.4
  TOP w0.121: v1(69.81,159.24) 75.17,159.24 79.64,163.71 98.26,163.71 98.82,163.16 98.82,161.05 J16.13 ; R445.2 v1(75.22,105.96)
  BOTTOM w0.121: v1(75.22,105.96) 74.95,106.23 74.95,120.17 74.8,120.32 74.8,120.42 70.96,124.26 70.96,134.86 69.75,136.06 69.75,140.57 69.92,140.73 69.92,147.74 69.63,148.02 69.63,151.68 69.92,151.96 69.92,155.49 69.81,155.59 v1(69.81,159.24)
MVRK_SPI_CS: length 3.3
  TOP w0.121: R452.2 J16.23
MVRK_SPI_SCLK: length 34
  TOP w0.121: v1(87.35,130.72) 87.1,130.97 R448.2
  BOTTOM w0.121: J16.17 92.62,156.53 87.22,151.13 87.22,148.87 85.28,146.93 85.28,135.7 87.22,133.76 87.22,131.34 87.35,131.21 v1(87.35,130.72)
MVRK_SPI_SIMO: length 3.2
  TOP w0.121: R451.2 J16.21
MVRK_SPI_SOMI: length 54.9
  TOP w0.121: v1(94.91,123.68) 94.51,123.29 89.75,123.29 89.05,122.59 R449.2
  BOTTOM w0.121: v1(94.91,123.68) 94.91,123.73 95.03,123.86 95.03,128.11 95.48,128.55 95.48,130.84 95.03,131.29 95.03,132.69 95.1,132.76 95.1,132.78 95.16,132.84 95.16,133.08 95.66,133.58 95.66,134.21 95.4,134.46 95.4,134.74 95.16,134.98 95.16,135.86 95.19,135.89 95.34,136.04 95.34,143.45 95.53,143.64 95.53,144.21 95.16,144.58 95.16,147.99 93.46,149.69 93.46,158.46 93.79,158.79 93.79,160.41 93.32,160.88 91.03,160.88 J16.19
MVRK_UART_RXD: length 120.9
  TOP w0.121: J16.3 111.67,161.2 111.67,163.36 110.58,164.45 79.29,164.45 75.14,160.31 69.15,160.31 v1(68.03,159.19) ; v1(73.76,94.27) R438.2
  BOTTOM w0.121: v1(68.03,159.19) 68.03,156.56 68.33,156.26 68.33,152.4 68.11,152.18 68.11,146.36 67.84,146.1 67.84,146.1 67.5,145.76 67.5,141.13 67.29,140.92 67.29,134.76 66.97,134.44 66.97,133.62 66.12,132.77 66.12,123.49 66.33,123.28 66.33,120.79 70.57,116.55 70.57,111.4 70.18,111.01 70.18,106.68 70.87,105.99 70.87,103.64 70.84,103.61 70.84,101.92 73.44,99.32 73.44,94.91 73.76,94.59 v1(73.76,94.27)
MVRK_UART_TXD: length 56.1
  TOP w0.121: v1(82.76,145.71) 93.08,145.71 93.27,145.9 94.45,145.9 97.25,148.69 112.61,148.69 113.06,149.14 v1(113.42,149.14) ; R436.2 v1(81.95,134.28)
  BOTTOM w0.121: v1(113.42,149.14) 113.42,152.59 112.94,153.07 J16.1 ; v1(81.95,134.28) 81.95,135.42 82.46,135.93 82.46,144.66 82.76,144.96 v1(82.76,145.71)
NAND_ADVN_ALE: length 12.2
  TOP w0.121: R137.1 141.48,98.34 142.14,99 144.18,99 144.61,99.42 149.61,99.42 151.26,97.78 U9.17
NAND_BE0N_CLE: length 11.4
  TOP w0.121: R136.1 142.4,95.8 143.29,94.91 147.29,94.91 147.54,95.16 147.54,95.22 148.12,95.8 150.63,95.8 150.76,95.93 U9.16
NAND_CSN: length 9
  TOP w0.121: R135.1 141.64,97.07 143.42,95.29 147.04,95.29 v1(147.1,95.35) 147.26,95.5 U9.9
  BOTTOM w0.121: R132.1 v1(147.1,95.35)
NAND_D0: length 19.5
  TOP w0.121: R140.1 150.1,106.84 152.76,109.51 U9.29
NAND_D1: length 18.3
  TOP w0.121: R141.1 150.66,108.24 152.26,109.84 U9.30
NAND_D2: length 16.6
  TOP w0.121: U9.31 151.76,110.87 150.53,109.64 R142.1
NAND_D3: length 14.7
  TOP w0.121: U9.32 151.26,112.4 149.77,110.91 R143.1
NAND_D4: length 9
  TOP w0.121: U9.41 146.76,113.49 145.83,112.56 141.52,112.56 R144.1
NAND_D5: length 7.2
  TOP w0.121: R145.1 145.2,113.58 146.26,114.64 U9.42
NAND_D6: length 7
  TOP w0.121: R146.1 142.15,113.96 145.07,113.96 145.76,114.65 U9.43
NAND_D7: length 6.6
  TOP w0.121: U9.44 145.26,115.29 144.31,114.34 142.53,114.34 141.18,115.68 141.18,116.19 R147.1
NAND_D8: length 75.5
  TOP w0.121: R148.1 107,93.64 107.29,93.93 115.53,93.93 115.86,93.6 116.74,93.6 117.36,94.22 124.06,94.22 v1(124.24,94.4) ; v1(140.12,117.26) 143.16,120.3 152.36,120.3 154.26,118.4 U9.26
  BOTTOM w0.121: v1(124.24,94.4) 124.69,94.84 128.94,94.84 129.39,94.4 131.99,94.4 132.43,94.84 133.32,94.84 133.64,95.16 135.93,95.16 136.94,96.18 136.94,96.81 136.05,97.7 135.17,97.7 134.7,98.16 134.7,99.22 135.69,100.2 136.19,100.2 138.85,102.86 138.85,104.62 139.17,104.94 139.17,113.26 140.12,114.21 v1(140.12,117.26)
NAND_D9: length 70.3
  TOP w0.121: v1(154.09,99.88) 154.09,99.89 153.41,100.57 144.17,100.57 143.86,100.26 138.91,100.26 136.74,98.08 131.24,98.08 128.68,95.52 127.44,95.52 127.19,95.27 124.14,95.27 123.4,94.53 106.34,94.53 105.91,94.95 105.11,94.95 104.69,94.53 104.69,94.27 R149.1 ; U9.27 153.76,115.43 v1(154.09,115.1)
  BOTTOM w0.121: v1(154.09,115.1) v1(154.09,99.88)
NAND_D10: length 71
  TOP w0.121: U9.28 v1(153.26,115.16) ; R150.1 110.53,88.82 116.86,88.82 117.2,89.15 128.99,89.15 129.95,90.11 131.49,90.11 132.45,89.15 143.31,89.15 144.72,90.56 149.68,90.56 150.79,91.67 151.74,91.67 153.07,93 v1(153.96,93)
  BOTTOM w0.121: v1(153.96,93) 153.96,97.93 153.26,98.63 v1(153.26,115.16)
NAND_D11: length 79.1
  TOP w0.102: 133.59,84.64 130.82,84.64 130.77,84.7 ; 135.17,84.64 137.96,84.64 138.04,84.72
  TOP w0.121: R151.1 109.64,82.45 109.88,82.21 112.49,82.21 114.08,83.81 122.29,83.81 125.89,87.41 127.65,87.41 127.93,87.13 127.93,85.38 128.61,84.7 130.77,84.7 ; 135.17,84.64 134.75,85.06 134.01,85.06 133.59,84.64 ; U9.33 v1(150.76,115.12) ; v1(150.25,85.99) 149.95,85.7 142.48,85.7 142.29,85.51 138.82,85.51 138.04,84.72
  BOTTOM w0.121: v1(150.25,85.99) 150.25,87.1 149.92,87.43 149.92,87.44 149.44,87.92 149.44,92.49 150.17,93.22 150.17,98.13 149.31,98.98 149.31,106.89 150.76,108.34 v1(150.76,115.12)
NAND_D12: length 64.8
  TOP w0.121: U9.40 147.26,115.35 v1(147.69,114.92) ; v1(148.12,90.08) 144.87,90.08 143.69,88.91 132.35,88.91 131.39,89.86 130.05,89.86 129.09,88.91 117.3,88.91 116.96,88.57 112.83,88.57 R152.1
  BOTTOM w0.121: v1(147.69,114.92) 147.69,114.77 148.12,114.34 148.12,99.4 147.64,98.92 147.64,94.25 148.12,93.76 v1(148.12,90.08)
NAND_D13: length 73.4
  TOP w0.121: U9.45 144.76,115.17 144.56,114.97 142.52,114.97 v1(141.96,115.53) ; R153.1 97.42,90.54 100.88,90.54 100.88,90.54 103.37,90.54 103.44,90.6 106.41,90.6 106.42,90.61 108.54,90.61 108.55,90.6 115.33,90.6 117.24,92.51 128.67,92.51 129.45,91.73 131.99,91.73 132.49,92.24 137.34,92.24 138.29,93.18 140.93,93.18 v1(141.13,93.38)
  BOTTOM w0.121: v1(141.13,93.38) 141.58,93.82 141.58,98.36 140.85,99.08 140.85,101.3 141.78,102.23 141.78,115.35 v1(141.96,115.53)
NAND_D14: length 66.6
  TOP w0.121: U9.46 v1(144.26,117.46) ; R154.1 99.35,94.98 100.16,95.79 103.32,95.79 105.1,97.57 118.78,97.57 120.05,98.84 123.11,98.84 124.37,97.58 129.72,97.58 132.27,100.13 136.37,100.13 136.92,100.68 138.52,100.68 138.69,100.51 143.25,100.51 v1(143.74,101)
  BOTTOM w0.121: v1(144.26,117.46) 143.79,117 143.79,101.05 v1(143.74,101)
NAND_D15: length 66.2
  TOP w0.121: R155.1 98.63,96.55 102.55,96.55 104.34,98.34 112.97,98.34 114.49,99.86 130.01,99.86 130.01,99.86 132.8,102.65 136.57,102.65 136.82,102.41 136.82,102.4 v1(137.07,102.15) ; v1(138.92,117.26) 139.36,116.82 141.23,116.82 142.33,117.92 143.52,117.92 143.76,117.68 U9.47
  BOTTOM w0.121: v1(137.07,102.15) 137.07,102.52 138.35,103.8 138.35,104.94 138.67,105.26 138.67,117.01 v1(138.92,117.26)
NAND_OEN: length 14.3
  TOP w0.121: R134.1 v1(147.57,104.18) ; v1(147.03,98.08) 146.76,97.81 U9.8
  BOTTOM w0.121: v1(147.57,104.18) 147.81,103.93 147.81,99.73 147.03,98.94 v1(147.03,98.08)
NAND_WAIT: length 13.9
  TOP w0.121: R133.1 144.51,102.78 144.72,102.98 v1(147.37,102.98) ; v1(146.26,98.08) 146.25,97.91 U9.7
  BOTTOM w0.121: R131.1 146.6,97.75 v1(146.26,98.08) 146.65,98.46 146.65,99.27 147.37,100 v1(147.37,102.98)
NAND_WEN: length 18.6
  TOP w0.121: v1(151.68,98.08) 151.75,98 U9.18 ; R138.1 147.71,105.57 147.76,105.62 v1(150.07,105.62)
  BOTTOM w0.121: v1(150.07,105.62) 150.93,104.77 150.93,101.29 151.95,100.27 151.95,98.36 v1(151.68,98.08)
NAND_WPN: length 17.7
  TOP w0.121: v1(151.4,101.74) 151.4,101.13 151.27,101 148.02,101 147,102.02 141.65,102.02 R139.1 ; v1(152.44,98.08) 152.25,97.9 U9.19
  BOTTOM w0.121: R130.1 v1(152.44,98.08) 152.44,100.7 v1(151.4,101.74)
Net_847: length 0.7
  TOP w0.121: 132.37,162.76 132.37,163.21 v1(132.5,163.38)
PB_INTERRUPT: length 5.7
  BOTTOM w0.121: R560.1 7.02,46.39 R113.2 6.9,45.78 6.92,45.76 R156.1 6.92,42.89 6.9,42.86 C118.1
PHY_LED_10/100N: length 1.6
  TOP w0.121: U25.26 v1(37.1,53.36)
  BOTTOM w0.381: C207.1 36.95,53.5 v1(37.1,53.36)
PHY_LED_1000N: length 52.2
  TOP w0.121: v1(44.61,7.28) R392.1 ; U25.24 36.77,52.08 38.77,50.08 v1(38.77,49.44) C206.1
  BOTTOM w0.121: v1(38.77,49.44) C206.1 39.23,48.55 45.5,42.28 45.5,8.17 v1(44.61,7.28)
PHY_LED_ACTN: length 67.5
  TOP w0.121: C205.1 v1(37.5,49.44) 37.63,49.57 37.63,50.08 36.36,51.35 35.22,51.35 34.98,51.58 U25.23 ; R390.1 22.92,6.23 v1(23.63,6.23)
  BOTTOM w0.121: v1(23.63,6.23) 24.65,6.23 27.55,9.13 38.98,9.13 43.62,13.78 43.62,41.41 38.09,46.95 38.09,48.09 37.63,48.55 C205.1 v1(37.5,49.44)
PHY_PPS/GPIO: length 2.6
  TOP w0.121: v1(34.62,51.23) 34.62,51.35 34.58,51.38 U25.22
  BOTTOM w0.121: v1(34.62,51.23) 34.62,51.35 34.58,51.39 34.58,52.11 34.84,52.36 R395.1
PM_ALERT: length 21.6
  TOP w0.121: U32.3 63.47,35.15 63.92,35.6 63.92,36.3 v1(65.89,38.26)
  BOTTOM w0.121: v1(65.89,38.26) 65.89,38.33 65.19,39.03 65.19,40.3 R455.1 J17.4 67.22,42.07 69.25,42.07 69.63,42.46 69.63,43.85 70.65,44.87 70.65,46.77 70.9,47.03 U27.3
PM_VDDAADCN: length 5.4
  BOTTOM w0.121: R501.3 46.01,75.35 J27.2 46.37,73.21 46.37,72.83 C372.2
  BOTTOM w0.127: R501.3 46.87,75.35 47.12,75.1
PM_VDDAADCP: length 8.8
  BOTTOM w0.121: C372.1 45.25,72.3 44.05,73.5 44.05,74.9 45.12,75.98 J27.1 46.01,76.11 R501.4
  BOTTOM w0.127: R501.4 46.87,76.11 47.15,76.39
PM_VDDCOREN: length 10
  TOP w0.121: R32.4 66.44,45.78 65.39,46.82 v1(65.39,47.74) 64.63,47.74 64.25,47.36 63.36,47.36 62.7,48.02 61.53,48.02 C353.2
  BOTTOM w0.121: U27.9 65.6,47.53 v1(65.39,47.74)
PM_VDDCOREP: length 7.6
  TOP w0.121: R32.3 66.32,48.53 66.28,48.49 v1(65.84,48.49) 64.91,48.49 64.08,47.65 63.71,47.65 62.68,48.68 C353.1
  BOTTOM w0.121: v1(65.84,48.49) 66.48,48.49 66.63,48.34 U27.10
PM_VDDMPUN: length 5.4
  TOP w0.121: R46.4 70.12,34.1 69.94,34.28 69.94,34.78 C356.2 68.19,35.47 68.01,35.65 U32.9
PM_VDDMPUP: length 4.7
  TOP w0.121: U32.10 68.29,36.15 68.31,36.13 68.9,36.13 C356.1 69.61,36.85 R46.3
PM_VDDSDDRMEMN: length 5
  TOP w0.121: R513.4 118.14,39.53 J41.2 120.05,39.66 C378.2
  TOP w0.127: R513.4 117.42,39.53 117.14,39.81
PM_VDDSDDRMEMP: length 5
  TOP w0.121: R513.3 118.4,38.78 J41.1 120.18,39.03 120.81,39.03 C378.1
  TOP w0.127: R513.3 117.42,38.78 117.16,38.52
PM_VDDSDDRN: length 5.6
  TOP w0.121: R508.4 113.63,67.48 J20.2
  TOP w0.127: R508.4 113.63,68.4 113.91,68.68
  BOTTOM w0.121: C361.2 113.7,67.41 J20.2
PM_VDDSDDRP: length 5.5
  TOP w0.121: R508.3 112.88,67.48 J20.1
  TOP w0.127: 112.63,68.65 112.88,68.4 R508.3
  BOTTOM w0.121: C361.1 111.99,68.55 J20.1
PM_VDDSHV1N: length 5.9
  TOP w0.121: C363.2 121.32,67.47 J26.2
  BOTTOM w0.121: J26.2 121.19,67.6 R493.3
  BOTTOM w0.127: 121.45,68.71 121.19,68.46 R493.3
PM_VDDSHV1P: length 5.8
  TOP w0.121: J26.1 119.67,68.11 120.31,68.74 C363.1
  BOTTOM w0.121: J26.1 119.67,67.47 120.43,68.24 120.43,68.32 R493.4
  BOTTOM w0.127: R493.4 120.44,68.46 120.16,68.74
PM_VDDSHV2N: length 5.1
  BOTTOM w0.121: R545.3 113.32,92.88 J38.2 115.86,91.99 C374.2
  BOTTOM w0.127: R545.3 113.32,93.8 113.57,94.05
PM_VDDSHV2P: length 8.1
  BOTTOM w0.121: C374.1 115.35,91.6 114.66,90.91 112.75,90.91 J38.1 112.56,92.88 R545.4
  BOTTOM w0.127: R545.4 112.56,93.8 112.28,94.08
PM_VDDSHV3N: length 6.4
  TOP w0.121: J39.2 131.61,139.67 R546.3 132.59,139.47 135.66,139.47 C375.2
  TOP w0.127: R546.3 132.53,139.67 132.79,139.92
PM_VDDSHV3P: length 6.5
  TOP w0.121: C375.1 135.7,139.21 132.68,139.21 R546.4 131.61,138.92 J39.1
  TOP w0.127: 132.81,138.64 132.53,138.92 R546.4
PM_VDDSHV4N: length 5.8
  TOP w0.121: J30.2 139.86,133.01 C365.2
  BOTTOM w0.121: J30.2 137.7,132.24 R494.3
  BOTTOM w0.127: R494.3 135.83,132.24 135.58,132.49
PM_VDDSHV4P: length 5.9
  TOP w0.121: J30.1 139.86,130.47 C365.1
  BOTTOM w0.121: R494.4 137.45,131.49 J30.1
  BOTTOM w0.127: R494.4 135.83,131.49 135.55,131.21
PM_VDDSHV5N: length 5.7
  TOP w0.121: C367.2 100.49,146.21 J32.2
  BOTTOM w0.121: R495.3 101.39,144.05 J32.2
  BOTTOM w0.127: R495.3 101.39,142.31 101.13,142.05
PM_VDDSHV5P: length 5.7
  TOP w0.121: J32.1 103.03,146.21 C367.1
  BOTTOM w0.121: R495.4 102.14,144.05 J32.1
  BOTTOM w0.127: 102.42,142.03 102.14,142.31 R495.4
PM_VDDSHV6N: length 4.8
  BOTTOM w0.121: R496.3 51.29,88.62 J34.2 48.87,89.51 C369.2
  BOTTOM w0.127: 51.03,87.7 51.29,87.95 R496.3
PM_VDDSHV6P: length 8
  BOTTOM w0.121: R496.4 52.04,88.62 J34.1 51.65,90.79 49.14,90.79 C369.1
  BOTTOM w0.127: R496.4 52.04,87.95 52.32,87.67
PM_VDDSN: length 5.8
  TOP w0.121: 100.62,118.66 100.62,116.62 C370.2
  BOTTOM w0.121: R498.3 101.51,117.76 100.62,118.66
  BOTTOM w0.127: 101.26,116.27 101.51,116.53 R498.3
PM_VDDSOSCN: length 5.9
  TOP w0.121: J29.2 113.19,58.97 C373.2
  BOTTOM w0.121: R506.3 113.83,61.64 J29.2
  BOTTOM w0.127: 114.08,63 113.83,62.74 R506.3
PM_VDDSOSCP: length 5.2
  TOP w0.121: C373.1 112.18,59.41 112.31,59.54 J29.1
  BOTTOM w0.121: R506.4 113.07,61.38 J29.1
  BOTTOM w0.127: R506.4 113.07,62.74 112.79,63.02
PM_VDDSP: length 5.9
  TOP w0.121: C370.1 103.16,116.88 J21.1
  BOTTOM w0.121: R498.4 102.27,117.76 J21.1
  BOTTOM w0.127: R498.4 102.27,116.53 102.55,116.25
PM_VDDSRTCN: length 5.5
  BOTTOM w0.121: C379.2 61.38,45.19 J35.2 61.69,47.28 R505.3
  BOTTOM w0.127: 61.95,48.52 61.69,48.27 R505.3
PM_VDDSRTCP: length 5.8
  BOTTOM w0.121: C379.1 61.07,44.68 61.07,45.37 J35.1 60.94,47.28 R505.4
  BOTTOM w0.127: R505.4 60.94,48.27 60.66,48.55
PM_VPLLCRLCDN: length 5.4
  TOP w0.121: J24.2 107.48,58.97 C371.2
  BOTTOM w0.121: J24.2 106.59,61.51 R503.3
  BOTTOM w0.127: R503.3 106.59,62.74 106.84,63
PM_VPLLCRLCDP: length 5.5
  TOP w0.121: J24.1 104.94,59.45 105.47,58.92 105.47,58.69 C371.1
  BOTTOM w0.121: R503.4 105.83,61.51 J24.1
  BOTTOM w0.127: R503.4 105.83,62.74 105.55,63.02
PM_VPLLDDRN: length 5.5
  BOTTOM w0.121: R507.4 60.87,53 J33.2 58.33,50.46 C368.2
  BOTTOM w0.127: 60.59,54.26 60.87,53.98 R507.4
PM_VPLLDDRP: length 8.5
  BOTTOM w0.121: R507.3 61.63,53 J33.1 61.43,51.01 59.68,51.01 59.02,50.35 59.02,49.62 C368.1
  BOTTOM w0.127: R507.3 61.63,53.98 61.88,54.24
PM_VPLLMPUN: length 6.1
  TOP w0.121: 95.29,116.87 95.49,116.67 95.49,114.54 95.16,114.21 C355.2 ; J22.2 95.29,117.64 R497.4
  TOP w0.127: 95.01,116.5 95.29,116.78 R497.4
PM_VPLLMPUP: length 6.1
  TOP w0.121: J22.1 95.92,117.77 95.92,117.04 R497.3 95.85,116.72 95.85,114.54 96.18,114.21 C355.1
  TOP w0.127: 96.3,116.53 96.05,116.78 R497.3
PM_VSRAMCOREN: length 5.1
  TOP w0.121: J23.2 44.49,102.91 C362.2
  BOTTOM w0.121: R500.4 46.52,102.27 J23.2
  BOTTOM w0.127: 47.91,102.55 47.63,102.27 R500.4
PM_VSRAMCOREP: length 5.1
  TOP w0.121: J23.1 44.23,100.37 C362.1
  BOTTOM w0.121: R500.3 47.03,101.51 J23.1
  BOTTOM w0.127: 47.89,101.26 47.63,101.51 R500.3
PM_VSRAMMPUN: length 4.9
  TOP w0.121: C360.2 44.61,97.45 J25.2
  BOTTOM w0.121: J25.2 46.9,96.55 R499.4
  BOTTOM w0.127: R499.4 47.63,96.55 47.91,96.83
PM_VSRAMMPUP: length 4.8
  TOP w0.121: J25.1 44.61,94.91 C360.1
  BOTTOM w0.121: J25.1 46.9,95.8 R499.3
  BOTTOM w0.127: R499.3 47.63,95.8 47.89,95.54
PM_VUSB1_8VN: length 5.8
  TOP w0.121: R502.4 115.61,143.92 J28.2 114.72,146.47 C364.2
  TOP w0.127: R502.4 115.61,142.18 115.33,141.9
PM_VUSB1_8VP: length 5.9
  TOP w0.121: R502.3 116.37,143.92 J28.1 117.26,145.96 C364.1
  TOP w0.127: R502.3 116.37,142.18 116.62,141.93
PM_VUSB3_3VN: length 5.9
  TOP w0.121: C366.2 107.61,146.21 J31.2 108.5,143.92 R504.4
  TOP w0.127: 108.22,141.9 108.5,142.18 R504.4
PM_VUSB3_3VP: length 5.8
  TOP w0.121: C366.1 110.15,146.21 J31.1 109.25,143.92 R504.3
  TOP w0.127: R504.3 109.25,142.18 109.51,141.93
PMIC_DELAYEDRTCPORZ: length 1.6
  TOP w0.121: R3.1 U1.2
PMIC_GPIO: length 127.9
  TOP w0.121: R3.2 59.27,101.97 59.27,99.66 60.04,98.88 60.18,98.88 v1(60.49,98.57) ; v1(56.5,39.79) 56.62,39.67 78.51,39.67 80.67,37.51 v1(82.21,37.51) ; C114.1 94.53,22.86 R69.1 94.53,24.17 94.27,24.42 92.95,24.42 92.06,25.31 86.79,25.31 86.4,25.7 86.4,26.45 85.89,26.96 81.46,26.96 80.98,26.48 79.51,26.48 78.02,27.98 v1(78.02,29.5)
  BOTTOM w0.121: v1(56.5,39.79) 57.39,40.67 57.39,57.01 58.46,58.08 58.46,69.06 61.42,72.03 62.37,72.98 62.37,80.86 61.99,81.25 61.99,81.29 61.96,81.32 61.96,82.74 61.32,83.38 61.32,86.29 60.89,86.72 60.6,87.01 60.6,87.42 60.6,88.01 59.46,89.15 59.46,89.15 59.46,92.07 59.55,92.16 59.55,93.66 59.55,94.32 60.6,95.38 60.6,98.01 60.49,98.13 v1(60.49,98.57) ; v1(82.21,37.51) 82.59,37.13 82.59,35.47 81.06,33.95 81.06,31.41 80.64,30.98 78.86,30.98 78.02,30.14 v1(78.02,29.5)
PMIC_I2C_SCL: length 149.5
  TOP w0.121: v1(140.58,58.28) 139.74,57.44 133.2,57.44 131.8,58.84 129.08,58.84 129.01,58.9 122.79,58.9 122.08,58.2 v1(121.58,58.2) ; v1(141.54,99.02) 141.36,98.84 138.89,98.84 137.97,97.91 137.97,96.43 137.08,95.54 132.37,95.54 131.54,94.71 131.54,94.63 131.23,94.31 R55.1
  TOP w0.203: U4.9 90.45,29.95 90.84,29.55 v1(90.84,28.99)
  LY3 w0.133: v1(90.84,28.99) 90.84,28.55 88.81,26.52 v1(85.36,26.52)
  BOTTOM w0.121: v1(90.84,28.99) 91.21,28.99 93.05,27.15 95.41,27.15 101.38,21.18 106.65,21.18 106.67,21.2 106.77,21.2 109.13,23.57 109.13,25.44 112.37,28.68 112.37,38.32 121.07,47.02 121.07,57.7 v1(121.58,58.2) ; R551.1 84.26,25.06 85.36,26.15 v1(85.36,26.52) ; v1(140.58,58.28) 140.58,58.71 140.6,58.74 140.6,65.94 141.38,66.72 141.38,71.57 141.9,72.08 141.9,75.38 143.29,76.78 143.29,82.72 143.1,82.91 143.1,87.63 141.82,88.91 141.82,98.74 v1(141.54,99.02)
PMIC_I2C_SDA: length 115.3
  TOP w0.121: R56.1 68.36,92.75 67.85,93.26 66.41,93.26 66.24,93.43 66.07,93.43 65.55,93.95 64.76,93.95 63.92,94.79 61.04,94.79 60.68,94.43 v1(60.68,93.76) ; v1(57.7,31.03) 74.48,31.03 79.31,26.2 81.05,26.2 81.56,26.71 84.25,26.71 v1(84.44,26.52) ; U4.8 90.05,29.66 v1(90.21,29.5)
  LY3 w0.133: v1(84.44,26.52) 85.14,27.22 87.92,27.22 v1(90.21,29.5)
  BOTTOM w0.121: v1(57.7,31.03) 57.38,31.34 57.38,39.81 57.63,40.07 57.63,56.87 59.41,58.65 59.41,69.31 61.63,71.53 62.87,72.77 62.87,81.07 62.53,81.4 62.53,81.44 62.48,81.5 62.48,81.51 62.45,81.54 62.45,82.95 61.82,83.58 61.82,86.49 61.1,87.21 61.1,88.22 59.96,89.36 59.96,91.87 60.05,91.96 60.05,93.13 v1(60.68,93.76) ; R550.1 84.12,26.2 v1(84.44,26.52)
PMIC_INTN: length 133
  TOP w0.121: R66.1 79.79,102.65 80.43,103.29 80.43,105.59 79.76,106.26 79.76,107.15 78.52,108.39 66.71,108.39 66.04,107.72 60.96,107.72 v1(60.49,107.25) ; U4.45 v1(85.52,32.69) ; v1(55.33,42.53) 55.56,42.3 58.81,42.3 59.74,41.38 71.4,41.38 71.98,40.8 79.03,40.8 v1(79.67,40.17)
  BOTTOM w0.121: v1(60.49,107.25) 59.12,105.88 59.12,103.21 58.07,102.16 58.07,99.81 58.07,93.05 58.07,92.78 57.98,92.69 57.98,90.18 57.98,88.53 58.27,88.24 58.56,87.95 58.81,87.7 59.1,87.41 59.1,86.32 59.84,85.58 59.84,82.76 60.47,82.13 60.47,81.29 60.47,72.96 57.17,69.65 57.17,68.57 57.17,58.69 56.15,57.67 56.15,43.35 v1(55.33,42.53) ; v1(79.67,40.17) 80.96,38.87 82.55,38.87 85.79,35.64 85.79,34.2 85.73,34.14 85.73,34.11 85.74,34.1 85.74,33.92 R67.1 85.52,33.42 v1(85.52,32.69)
PMIC_PWR_EN: length 252.1
  TOP w0.102: v2(79.4,81.8) U2.C6
  TOP w0.121: v1(136.94,93.51) 137.6,94.17 139.19,94.17 140.04,95.02 142.65,95.02 143.14,94.53 143.9,94.53 v1(144.41,94.02) ; v1(134.17,39.79) 131.99,39.79 129.7,42.07 v1(129.7,42.71) 129.7,44.3 128.24,45.76 113.68,45.76 113.17,45.25 97.37,45.25 95.46,47.15 80.68,47.15 80.62,47.1 80.18,47.1 v1(79.87,47.41) 79.26,47.41 79.07,47.6 74.14,47.6 72.15,49.59 66.74,49.59 66.08,48.93 65.12,48.93 64.93,48.74 v1(64.43,48.74)
  BOTTOM w0.102: 77.1,80.69 77.96,81.55 79.15,81.55 v2(79.4,81.8)
  BOTTOM w0.121: v1(79.87,47.41) 78.88,46.42 78.88,44.74 83.35,40.27 R65.2 83.35,38.52 86.04,35.83 86.04,32.07 R556.2 ; 77.1,80.69 77.08,80.69 76.73,80.34 76.25,80.34 76.06,80.15 73.96,80.15 73.91,80.1 72.3,80.1 72.25,80.15 70.24,80.15 69.38,79.29 69.38,72.3 66.97,69.89 66.97,68.8 66.87,68.7 66.87,68.62 65.19,66.94 65.19,62.32 65.7,61.81 65.7,58.84 64.98,58.13 64.98,57.26 65.38,56.87 65.38,52.13 65.12,51.87 65.12,50.65 64.43,49.95 v1(64.43,48.74) ; v1(144.41,94.02) 144.41,88.94 145.45,87.9 145.45,82.97 144.8,82.31 144.8,76.16 144.21,75.57 144.21,59.11 134.96,49.86 134.96,46.86 134.22,46.11 134.22,41.24 134.17,41.19 v1(134.17,39.79) ; v1(129.7,42.71) 129.7,41.69 130.09,41.31 130.09,29.91 135.93,24.07 135.93,22.39 137.45,20.87 137.45,19.34 137.83,18.96 138.59,18.96 138.72,19.09 142.66,19.09 144.31,20.74 R478.2 ; v1(136.94,93.51) 135.91,92.47 133.83,92.47 133.76,92.55 132.76,92.55 132.69,92.47 131.76,92.47 R178.1

# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_LAYOUT_REV1_6A.brd (continued)
## Nets (continued)
AM335X_GPMC_CS0N: R135.2(P2) R183.2(P2) U2.V6(GPMC_CSN0)
AM335X_GPMC_CS1N: R175.1(P1) R638.2(P2) U2.U9(GPMC_CSN1)
AM335X_GPMC_CS2N: R173.1(P1) U2.V9(GPMC_CSN2)
AM335X_GPMC_CS3N: R460.2(P2) U2.T13(GPMC_CSN3)
AM335X_GPMC_OEN_REN: R134.2(P2) R189.2(P2) U2.T7(GPMC_OEN_REN)
AM335X_GPMC_WAIT: R133.2(P2) R179.2(P2) U2.T17(GPMC_WAIT0)
AM335X_GPMC_WEN: R138.2(P2) R191.2(P2) U2.U6(GPMC_WEN)
AM335X_GPMC_WPN: R139.2(P2) R180.2(P2) U2.U17(GPMC_WPN)
AM335X_I2C0_SCL: R58.2(P2) R265.2(P2) R547.1(P1) R551.2(P2) U2.C16(I2C0_SCL) U7.6(SCL)
AM335X_I2C0_SDA: R59.2(P2) R268.2(P2) R548.1(P1) R550.2(P2) U2.C17(I2C0_SDA) U7.5(SDA)
AM335X_LCD_AC_BIAS_EN: R273.2(P2) R312.2(P2) U2.R6(LCD_AC_BIAS_EN)
AM335X_LCD_DATA0: R96.1(P1) R240.2(P2) R299.2(P2) SW3.16 U2.R1(LCD_DATA0)
AM335X_LCD_DATA1: R97.1(P1) R241.2(P2) R300.2(P2) SW3.15 U2.R2(LCD_DATA1)
AM335X_LCD_DATA2: R98.1(P1) R245.2(P2) R301.2(P2) SW3.14 U2.R3(LCD_DATA2)
AM335X_LCD_DATA3: R99.1(P1) R246.2(P2) R302.2(P2) SW3.13 U2.R4(LCD_DATA3)
AM335X_LCD_DATA4: R100.1(P1) R251.2(P2) R303.2(P2) SW3.12 U2.T1(LCD_DATA4)
AM335X_LCD_DATA5: R101.1(P1) R252.2(P2) R288.2(P2) SW3.11 U2.T2(LCD_DATA5)
AM335X_LCD_DATA6: R102.1(P1) R270.2(P2) R289.2(P2) SW3.10 U2.T3(LCD_DATA6)
AM335X_LCD_DATA7: R103.1(P1) R259.2(P2) R290.2(P2) SW3.9 U2.T4(LCD_DATA7)
AM335X_LCD_DATA8: R104.1(P1) R262.2(P2) R291.2(P2) SW4.16 U2.U1(LCD_DATA8)
AM335X_LCD_DATA9: R105.1(P1) R266.2(P2) R293.2(P2) SW4.15 U2.U2(LCD_DATA9)
AM335X_LCD_DATA10: R106.1(P1) R256.2(P2) R294.2(P2) SW4.14 U2.U3(LCD_DATA10)
AM335X_LCD_DATA11: R107.1(P1) R267.2(P2) R281.2(P2) SW4.13 U2.U4(LCD_DATA11)
AM335X_LCD_DATA12: R108.1(P1) R257.2(P2) R282.2(P2) SW4.12 U2.V2(CD_DATA12)
AM335X_LCD_DATA13: R109.1(P1) R258.2(P2) R283.2(P2) SW4.11 U2.V3(LCD_DATA13)
AM335X_LCD_DATA14: R110.1(P1) R260.2(P2) R284.2(P2) SW4.10 U2.V4(LCD_DATA14)
AM335X_LCD_DATA15: R111.1(P1) R254.2(P2) R285.2(P2) SW4.9 U2.T5(LCD_DATA15)
AM335X_LCD_HSYNC: R272.2(P2) R311.2(P2) U2.R5(LCD_HSYNC)
AM335X_LCD_PCLK: R269.2(P2) R307.2(P2) U2.V5(LCD_PCLK)
AM335X_LCD_VSYNC: R271.2(P2) R305.2(P2) U2.U5(LCD_VSYNC)
AM335X_MCASP0_ACLKR: R88.2(P2) R218.2(P2) R379.2(P2) U2.B12(MCASP0_ACLKR)
AM335X_MCASP0_ACLKX: R194.1(P1) R346.1(P1) R448.1(P1) U2.A13(MCASP0_ACLKX)
AM335X_MCASP0_AHCLKR: R85.2(P2) R211.1(P1) R328.1(P1) R452.1(P1) U2.C12(MCASP0_AHCLKR)
AM335X_MCASP0_AHCLKX: R92.2(P2) R234.2(P2) R319.2(P2) R352.1(P1) U2.A14(MCASP0_AHCLKX)
AM335X_MCASP0_AXR0: R203.1(P1) R347.1(P1) R451.1(P1) U2.D12(MCASP0_AXR0)
AM335X_MCASP0_AXR1: R227.2(P2) R318.2(P2) R348.1(P1) U2.D13(MCASP0_AXR1)
AM335X_MCASP0_FSR: R90.2(P2) R224.2(P2) R336.1(P1) U2.C13(MCASP0_FSR)
AM335X_MCASP0_FSX: R199.1(P1) R335.1(P1) R449.1(P1) U2.B13(MCASP0_FSX)
AM335X_MMC2_CLK: R459.1(P1) U28.9(CLKA)
AM335X_MMC2_CMD: R460.1(P1) U28.4(CMDA)
AM335X_MMC2_D0: R456.1(P1) U28.6(DAT0A)
AM335X_MMC2_D1: R457.1(P1) U28.7(DAT1A)
AM335X_MMC2_D2: R458.1(P1) U28.1(DAT2A)
AM335X_MMC2_D3: R491.1(P1) U28.3(DAT3A)
AM335X_MMC_CLK: R197.2(P2) R398.2(P2) U2.G17(MMC0_CLK)
AM335X_MMC_CMD: R200.2(P2) R397.2(P2) U2.G18(MMC0_CMD)
AM335X_MMC_D0: R204.2(P2) R399.2(P2) U2.G16(MMC0_DAT0)
AM335X_MMC_D1: R212.2(P2) R400.2(P2) U2.G15(MMC0_DAT1)
AM335X_MMC_D2: R215.2(P2) R401.2(P2) U2.F18(MMC0_DAT2)
AM335X_MMC_D3: R219.2(P2) R396.2(P2) U2.F17(MMC0_DAT3)
AM335X_OSC0_IN: C4.1 R7.2(P2) U2.V10(XTALIN) Y2.3
AM335X_OSC0_OUT: R8.1(P1) U2.U11(XTALOUT)
AM335X_OSC1_IN: C2.2 U2.A6(RTC_XTALIN) Y1.4
AM335X_OSC1_OUT: R5.1(P1) U2.A4(RTC_XTALOUT)
AM335X_PORZ: R2.1(P1) R9.2(P2) U2.B15(PWRONRSTN)
AM335X_RTC_PORZ: R4.2(P2) U1.4(Y) U2.B5(RTC_PWRONRSTN)
AM335X_SPI0_CS0: R55.2(P2) R176.2(P2) R313.2(P2) R552.1(P1) U2.A16(SPI0_CS0)
AM335X_SPI0_CS1: R78.2(P2) R208.1(P1) R380.2(P2) U2.C15(SPI0_CS1)
AM335X_SPI0_D0: R205.1(P1) R436.1(P1) U2.B17(SPI0_D0)
AM335X_SPI0_D1: R56.2(P2) R177.1(P1) R314.2(P2) R553.1(P1) U2.B16(SPI0_D1)
AM335X_SPI0_SCLK: R201.1(P1) R438.1(P1) U2.A17(SPI0_SCLK)
AM335X_UART0_CTSN: R61.2(P2) R213.1(P1) R364.2(P2) U2.E18(UART0_CTSN)
AM335X_UART0_RTSN: R62.2(P2) R216.1(P1) R362.2(P2) U2.E17(UART0_RTSN)
AM335X_UART0_RXD: R220.1(P1) R249.2(P2) R363.2(P2) U2.E15(UART0_RXD)
AM335X_UART0_TXD: R222.1(P1) R244.2(P2) R361.2(P2) U2.E16(UART0_TXD)
AM335X_UART1_CTSN: R84.2(P2) R225.1(P1) R357.1(P1) R445.1(P1) R555.1(P1) U2.D18(UART1_CTSN)
AM335X_UART1_RTSN: R87.2(P2) R229.1(P1) R355.1(P1) R443.1(P1) R554.1(P1) U2.D17(UART1_RTSN)
AM335X_UART1_RXD: R89.2(P2) R232.1(P1) R356.1(P1) U2.D16(UART1_RXD)
AM335X_UART1_TXD: R91.2(P2) R236.1(P1) R354.1(P1) U2.D15(UART1_TXD)
AM335X_USB0_CE: TP23.1 U2.M15(USB0_CE)
AM335X_USB0_DRVVBUS: R383.1(P1) U2.F16(USB0_DRVVBUS) U22.4(EN)
AM335X_USB0_VBUS: D9.1(CATHODE) R563.1(P1) U2.P15(USB0_VBUS)
AM335X_USB1_CE: TP36.1 U2.P18(USB1_CE)
AM335X_USB1_DRVVBUS: R387.1(P1) U2.F15(USB1_DRVVBUS) U29.4(EN)
AM335X_USB1_VBUS: D10.1(CATHODE) R564.1(P1) U2.T18(USB1_VBUS)
AM335X_VDDA_ADC: C63.1 R501.1(I1) U2.D8(VDDA_ADC)
AM335X_VDDS: C48.1 C50.1 C89.1 C96.1 C249.1 R498.1(I1) U2.E6(VDDS#E6) U2.E14(VDDS#E14) U2.F9(VDDS#F9) U2.K13(VDDS#K13) U2.N6(VDDS#N6) U2.P9(VDDS#P9) U2.P14(VDDS#P14)
AM335X_VDDS_DDR: C76.1 C77.1 C78.1 C79.1 C80.1 C82.1 C233.1 C309.1 R508.2(I2) U2.E5(VDDS_DDR#E5) U2.F5(VDDS_DDR#F5) U2.G5(VDDS_DDR#G5) U2.H5(VDDS_DDR#H5) U2.J5(VDDS_DDR#J5) U2.K5(VDDS_DDR#K5) U2.L5(VDDS_DDR#L5)
AM335X_VDDSHV1: C31.1 C32.1 C258.1 R493.1(I1) U2.P7(VDDSHV1#P7) U2.P8(VDDSHV1#P8)
AM335X_VDDSHV2: C90.1 C92.1 C259.1 R545.1(I1) U2.P10(VDDSHV2#P10) U2.P11(VDDSHV2#P11)
AM335X_VDDSHV3: C93.1 C94.1 C273.1 R546.1(I1) U2.P12(VDDSHV3#P12) U2.P13(VDDSHV3#P13)
AM335X_VDDSHV4: C42.1 C43.1 C274.1 R494.1(I1) U2.H14(VDDSHV4#H14) U2.J14(VDDSHV4#J14)
AM335X_VDDSHV5: C45.1 C46.1 C257.1 R495.1(I1) U2.K14(VDDSHV5#K14) U2.L14(VDDSHV5#L14)
AM335X_VDDSHV6: C25.1 C27.1 C28.1 C29.1 C30.1 C47.1 C247.1 R496.1(I1) U2.E10(VDDSHV6#E10) U2.E11(VDDSHV6#E11) U2.E12(VDDSHV6#E12) U2.E13(VDDSHV6#E13) U2.F14(VDDSHV6#F14) U2.G14(VDDSHV6#G14) U2.N5(VDDSHV6#N5) U2.P5(VDDSHV6#P5) U2.P6(VDDSHV6#P6)
AM335X_XDMA_EVENT_INTR0: R76.2(P2) R221.2(P2) R349.1(P1) TP31.1 U2.A15(XDMA_EVENT_INTR0)
AM335X_XDMA_EVENT_INTR1: R77.2(P2) R228.2(P2) R250.2(P2) R315.2(P2) R351.1(P1) TP32.1 U2.D14(XDMA_EVENT_INTR1)
CAP_VBB_MPU: C72.1 U2.C10(CAP_VBB_MPU)
CAP_VDD_SRAM_CORE: C60.1 U2.D9(CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU: C71.1 U2.D11(CAP_VDD_SRAM_MPU)
COM_AUD_CLK: J11.52 R338.2(P2)
COM_AUD_FSYNC: J11.54 R339.2(P2)
COM_AUD_IN: J11.56 R340.2(P2)
COM_AUD_OUT: J11.58 R341.2(P2)
COM_BTRST: J11.89 R353.1(P1)
COM_BTUARTCTS: J11.70 R344.2(P2)
COM_BTUARTDEBUG: J11.76 TP45.1
COM_BTUARTRTS: J11.72 R345.2(P2)
COM_BTUARTRX: J11.68 R343.2(P2)
COM_BTUARTTX: J11.66 R342.2(P2)
COM_GNSS_PPS_OUT: J11.50 U14.10(2B2)
COM_GNSS_TIME_STAMP: J11.48 U13.10(2B2)
COM_SDIO_CLK: J11.20 R334.1(P1) R485.2(P2)
COM_SDIO_CMD: J11.24 R333.1(P1) R486.2(P2)
COM_SDIO_D0: J11.26 R332.1(P1) R487.2(P2)
COM_SDIO_D1: J11.28 R331.1(P1) R488.2(P2)
COM_SDIO_D2: J11.30 R330.1(P1) R489.2(P2)
COM_SDIO_D3: J11.32 R329.1(P1) R490.2(P2)
COM_SLOW_CLK: J11.1 U15.12(1B2)
COM_WL_IRQ: J11.34 R337.2(P2)
COM_WL_RS232_RX: J11.13 TP43.1
COM_WL_RS232_TX: J11.11 TP42.1
COM_WL_RST: J11.4 R327.2(P2)
COM_WL_UART_DBG: J11.15 TP44.1
COMAUD_CLK: R338.1(P1) U14.13(1B1)
COMAUD_FSYNC: R339.1(P1) U13.11(2B1)
COMAUD_IN: R340.1(P1) U14.12(1B2)
COMAUD_OUT: R341.1(P1) U14.11(2B1)
COMBTRST: R353.2(P2) U15.10(2B2)
COMBTUARTCTS: R344.1(P1) U16.12(1B2)
COMBTUARTRTS: R345.1(P1) U16.10(2B2)
COMBTUARTRX: R343.1(P1) U16.13(1B1)
COMBTUARTTX: R342.1(P1) U16.11(2B1)
COMWL_IRQ: R337.1(P1) U13.13(1B1)
COMWL_RST: R327.1(P1) U15.13(1B1)
DDR_A0: R604.2(P2) U2.F3(DDR_A0) U33.K3(A0) U34.K3(A0)
DDR_A1: R605.2(P2) U2.H1(DDR_A1) U33.L7(A1) U34.L7(A1)
DDR_A2: R606.2(P2) U2.E4(DDR_A2) U33.L3(A2) U34.L3(A2)
DDR_A3: R607.2(P2) U2.C3(DDR_A3) U33.K2(A3) U34.K2(A3)
DDR_A4: R608.2(P2) U2.C2(DDR_A4) U33.L8(A4) U34.L8(A4)
DDR_A5: R609.2(P2) U2.B1(DDR_A5) U33.L2(A5) U34.L2(A5)
DDR_A6: R610.2(P2) U2.D5(DDR_A6) U33.M8(A6) U34.M8(A6)
DDR_A7: R611.2(P2) U2.E2(DDR_A7) U33.M2(A7) U34.M2(A7)
DDR_A8: R612.2(P2) U2.D4(DDR_A8) U33.N8(A8) U34.N8(A8)
DDR_A9: R613.2(P2) U2.C1(DDR_A9) U33.M3(A9) U34.M3(A9)
DDR_A10: R614.2(P2) U2.F4(DDR_A10) U33.H7(A10/AP) U34.H7(A10/AP)
DDR_A11: R615.2(P2) U2.F2(DDR_A11) U33.M7(A11) U34.M7(A11)
DDR_A12: R616.2(P2) U2.E3(DDR_A12) U33.K7(A12/B\C\) U34.K7(A12/B\C\)
DDR_A13: R617.2(P2) U2.H3(DDR_A13) U33.N3(A13) U34.N3(A13)
DDR_A14: R618.2(P2) U2.H4(DDR_A14) U33.N7(A14) U34.N7(A14)
DDR_A15: R619.2(P2) U2.D3(DDR_A15) U33.J7(A15) U34.J7(A15)
DDR_BA0: R620.2(P2) U2.C4(DDR_BA0) U33.J2(BA0) U34.J2(BA0)
DDR_BA1: R621.2(P2) U2.E1(DDR_BA1) U33.K8(BA1) U34.K8(BA1)
DDR_BA2: R622.2(P2) U2.B3(DDR_BA2) U33.J3(BA2) U34.J3(BA2)
DDR_CASN: R601.2(P2) U2.F1(DDR_CASN) U33.G3(CASN) U34.G3(CASN)
DDR_CKE: R598.2(P2) R633.2(P2) R635.2(P2) U2.G3(DDR_CKE) U33.G9(CKE) U34.G9(CKE)
DDR_CLK: R624.2(P2) U2.D2(DDR_CK) U33.F7(CK) U34.F7(CK)
DDR_CLKN: R625.2(P2) U2.D1(DDR_CKN) U33.G7(CKN) U34.G7(CKN)
DDR_CSN0: R599.2(P2) U2.H2(DDR_CSN0) U33.H2(CSN) U34.H2(CSN)
DDR_D0: U2.M3(DDR_D0) U33.B3(DQ0)
DDR_D1: U2.M4(DDR_D1) U33.C7(DQ1)
DDR_D2: U2.N1(DDR_D2) U33.C2(DQ2)
DDR_D3: U2.N2(DDR_D3) U33.C8(DQ3)
DDR_D4: U2.N3(DDR_D4) U33.E3(DQ4)
DDR_D5: U2.N4(DDR_D5) U33.E8(DQ5)
DDR_D6: U2.P3(DDR_D6) U33.D2(DQ6)
DDR_D7: U2.P4(DDR_D7) U33.E7(DQ7)
DDR_D8: U2.J1(DDR_D8) U34.B3(DQ0)
DDR_D9: U2.K1(DDR_D9) U34.C7(DQ1)
DDR_D10: U2.K2(DDR_D10) U34.C2(DQ2)
DDR_D11: U2.K3(DDR_D11) U34.C8(DQ3)
DDR_D12: U2.K4(DDR_D12) U34.E3(DQ4)
DDR_D13: U2.L3(DDR_D13) U34.E8(DQ5)
DDR_D14: U2.L4(DDR_D14) U34.D2(DQ6)
DDR_D15: U2.M1(DDR_D15) U34.E7(DQ7)
DDR_DQM0: U2.M2(DDR_DQM0) U33.B7(DM)
DDR_DQM1: U2.J2(DDR_DQM1) U34.B7(DM)
DDR_DQS0: U2.P1(DDR_DQS0) U33.C3(DQS)
DDR_DQS1: U2.L1(DDR_DQS1) U34.C3(DQS)
DDR_DQSN0: U2.P2(DDR_DQSN0) U33.D3(DQSN)
DDR_DQSN1: U2.L2(DDR_DQSN1) U34.D3(DQSN)
DDR_ODT: R623.2(P2) U2.G1(DDR_ODT) U33.G1(ODT) U34.G1(ODT)
DDR_RASN: R600.2(P2) U2.G4(DDR_RASN) U33.F3(RASN) U34.F3(RASN)
DDR_RESETN: R630.1(P1) U2.G2(DDR_RESETN) U33.N2(RESETN) U34.N2(RESETN)
DDR_WEN: R602.2(P2) U2.B2(DDR_WEN) U33.H3(WEN) U34.H3(WEN)
EECS: U58.63(EECS) U61.1(CS)
EEDATA: R587.1(P1) U58.61(EEDATA) U61.3(DI)
EESK: U58.62(EESK) U61.2(CLK)
EMU2: J2.17(EMU2) R76.1(P1)
EMU3: J2.18(EMU3) R77.1(P1)
EMU4: J2.19(EMU4) R78.1(P1)
EMU_RSTN: C260.1 J2.15(SRST) R517.1(P1)
EMU_USB_DM: J40.2(DM) U57.5(IO2) U58.7(DM)
EMU_USB_DP: J40.3(DP) U57.3(IO1) U58.8(DP)
ENZ_KALDO_1P8V: R48.2(P2) U2.B4(RTC_KALDO_ENN)
ETH_INTN: R404.1(P1) R409.1(P1) U25.5(INT)
ETH_MDIO_CLK: R407.2(P2) R433.1(P1) U25.1(MDC)
ETH_MDIO_DATA: R408.1(P1) R434.1(P1) U25.48(MDIO)
ETH_RBIAS: R406.2(P2) U25.9(RBIAS)
ETH_REFCLK: R432.1(P1) U25.25(CLK_25M)
ETH_RESETN: R391.1(P1) U25.2(R\S\T\) U26.4(Y)
ETH_RXCLK: R422.2(P2) R423.1(P1) U25.33(RX_CLK)
ETH_RXD0: R411.2(P2) R424.1(P1) U25.31(RXD0)
ETH_RXD1: R413.2(P2) R425.1(P1) U25.30(RXD1)
ETH_RXD2: R419.2(P2) R427.1(P1) U25.28(RXD2)
ETH_RXD3: R426.2(P2) R428.1(P1) U25.27(RXD3)
ETH_RXDV: R414.2(P2) R430.1(P1) U25.32(RX_DV)
ETH_TXCLK: R415.1(P1) U25.35(GTX_CLK)
ETH_TXD0: R416.1(P1) U25.36(TXD0)
ETH_TXD1: R417.1(P1) U25.37(TXD1)
ETH_TXD2: R418.1(P1) U25.38(TXD2)
ETH_TXD3: R420.1(P1) U25.39(TXD3)
ETH_TXEN: R421.1(P1) U25.34(TX_EN)
ETHER_D0N: J15.10 U25.12(TRXN0)
ETHER_D0P: J15.9 U25.11(TRXP0)
ETHER_D1N: J15.8 U25.15(TRXN1)
ETHER_D1P: J15.7 U25.14(TRXP1)
ETHER_D2N: J15.6 U25.18(TRXN2)
ETHER_D2P: J15.5 U25.17(TRXP2)
ETHER_D3N: J15.4 U25.21(TRXN3)
ETHER_D3P: J15.3 U25.20(TRXP3)
EXP0_P25: J3.25 R178.2(P2)
EXP3_P9: J6.9 TP35.1
EXP_ECAP0_IN_PWM0_OUT: J5.19 R210.2(P2)
EXP_GPMC_ADVN_ALE: J4.26 R182.1(P1)
EXP_GPMC_BE0N_CLE: J4.28 R184.1(P1)
EXP_GPMC_BE1N: J5.2 R186.1(P1)
EXP_GPMC_CLK: J4.23 R181.1(P1)
EXP_GPMC_CS0N: J4.25 R183.1(P1)
EXP_GPMC_CS3N: J5.4 R187.1(P1)
EXP_GPMC_OEN_REN: J5.6 R189.1(P1)
EXP_GPMC_WAIT: J4.19 R179.1(P1)
EXP_GPMC_WEN: J5.8 R191.1(P1)
EXP_GPMC_WPN: J4.21 R180.1(P1)
EXP_I2C1_SCL: J3.24 R176.1(P1)
EXP_I2C1_SDA: J3.23 R177.2(P2)
EXP_MII1_COL: J5.34 R231.1(P1)
EXP_MII1_CRS: J5.36 R235.1(P1)
EXP_MII1_RXERR: J5.38 R237.1(P1)
EXP_MMC0_CLK: J5.12 R197.1(P1)
EXP_MMC0_CMD: J5.14 R200.1(P1)
EXP_MMC0_DAT0: J5.16 R204.1(P1)
EXP_MMC0_DAT1: J5.22 R212.1(P1)
EXP_MMC0_DAT2: J5.24 R215.1(P1)
EXP_MMC0_DAT3: J5.26 R219.1(P1)
EXP_MMC1_CLK: J3.21 R175.2(P2)
EXP_MMC1_CMD: J3.19 R173.2(P2)
EXP_MMC1_DAT0: J3.17 R171.2(P2)
EXP_MMC1_DAT1: J3.15 R169.2(P2)
EXP_MMC1_DAT2: J3.13 R167.2(P2)
EXP_MMC1_DAT3: J3.11 R165.2(P2)
EXP_MMC1_DAT4: J3.9 R163.2(P2)
EXP_MMC1_DAT5: J3.7 R161.2(P2)
EXP_MMC1_DAT6: J3.5 R159.2(P2)
EXP_MMC1_DAT7: J3.3 R157.2(P2)
EXP_PB_POWERON: J4.12 R63.2(P2)
EXP_RMII1_REFCLK: J5.3 R188.2(P2)
EXP_SPI0_CLK: J5.13 R201.2(P2)
EXP_SPI0_CS1: J5.17 R208.2(P2)
EXP_SPI0_D0: J5.15 R205.2(P2)
EXP_UART0_CTSN: J5.21 R213.2(P2)
EXP_UART0_RTSN: J5.23 R216.2(P2)
EXP_UART0_RXD: J5.25 R220.2(P2)
EXP_UART0_TXD: J5.27 R222.2(P2)
EXP_UART1_CTSN: J5.29 R225.2(P2)
EXP_UART1_RTSN: J5.31 R229.2(P2)
EXP_UART1_RXD: J5.33 R232.2(P2)
EXP_UART1_TXD: J5.35 R236.2(P2)
EXP_WAKEUP: J5.18 R207.1(P1)
EXP_XDMA_EVENT_INTR0: J5.28 R221.1(P1)
EXP_XDMA_EVENT_INTR1: J5.32 R228.1(P1)
F_ADBUS0: R576.2(P2) U58.16(ADBUS0)
F_ADBUS1: R577.2(P2) U58.17(ADBUS1)
F_ADBUS2: R578.2(P2) U58.18(ADBUS2)
F_ADBUS3: R579.2(P2) U58.19(ADBUS3)
F_ADBUS4: R580.2(P2) U58.21(ADBUS4)
F_ADBUS5: R581.2(P2) U58.26(ACBUS0)
F_ADBUS6: R582.2(P2) U58.23(ADBUS6)
F_ADBUS7: R583.2(P2) U58.30(ACBUS4)
FT_SRESET: R581.1(P1) R626.2(P2) U55.1(A)
FT_SRESETB: R575.2(P2) U60.6(1Y)
FT_SRESETN: U55.4(Y) U60.1(1A)
FT_VBUS: R590.1(P1) U55.2(B)
FTDI_REF: R584.1(P1) U58.6(REF)
FTDI_VPHY: C320.2 C323.2 FB23.1 U58.4(VPHY)
FTDI_VPLL: C326.2 C329.2 FB24.1 U58.9(VPLL)
GPMC_A0: J6.2 R193.1(P1)
GPMC_A1: J6.4 R196.1(P1)
GPMC_A2: J6.6 R198.1(P1)
GPMC_A3: J6.8 R202.1(P1)
GPMC_A4: J6.10 R206.1(P1)
GPMC_A5: J6.12 R209.1(P1)
GPMC_A6: J6.16 R214.1(P1)
GPMC_A7: J6.18 R217.1(P1)
GPMC_A8: J6.22 R223.1(P1)
GPMC_A9: J6.24 R226.1(P1)
GPMC_A10: J6.26 R230.1(P1)
GPMC_A11: J6.28 R233.1(P1)
HDMI_AUDBCLK: R316.1(P1) U10.45(SCK)
HDMI_AUDD0: R318.1(P1) U10.41(SD0)
HDMI_AUDD1: R319.1(P1) U10.40(SD1)
HDMI_AUDD2: R320.1(P1) U10.39(SD2)
HDMI_AUDD3: R321.1(P1) U10.37(SD3)
HDMI_AUDFSX: R317.1(P1) U10.44(WS)
HDMI_AUDMCLK: R315.1(P1) U10.38(MCLK)
HDMI_AVCC12: C153.1 C154.1 C244.1 FB13.1 U10.60(AVCC12#60) U10.66(AVCC12#66)
HDMI_CEC: R277.1(P1) U10.71(CEC_A) U11.1(CEC_A)
HDMI_CEC_D: R296.1(P1) U10.50(CEC_D)
HDMI_CLK+: J10.10(CLK+) U10.59(TXC+) U11.16(TMDS_CK+)
HDMI_CLK-: J10.12(CLK-) U10.58(TXC-) U11.15(TMDS_CK-)
HDMI_CT_HPD: R322.2(P2) R323.1(P1) U11.12(CT_HPD)
HDMI_CVCC12: C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 FB11.1 U10.5(CVCC12#5) U10.12(CVCC12#12) U10.26(CVCC12#26) U10.42(CVCC12#42) U10.47(CVCC12#47) U10.53(CVCC12#53)
HDMI_D0: R278.1(P1) U10.32(VDATA_IN0)
HDMI_D1: R279.1(P1) U10.31(VDATA_IN1)
HDMI_D2: R280.1(P1) U10.30(VDATA_IN2)
HDMI_D3: R281.1(P1) U10.29(VDATA_IN3)
HDMI_D4: R282.1(P1) U10.28(VDATA_IN4)
HDMI_D5: R283.1(P1) U10.27(VDATA_IN5)
HDMI_D6: R284.1(P1) U10.25(VDATA_IN6)
HDMI_D7: R285.1(P1) U10.24(VDATA_IN7)
HDMI_D8: R286.1(P1) U10.23(VDATA_IN8)
HDMI_D9: R287.1(P1) U10.20(VDATA_IN9)
HDMI_D10: R288.1(P1) U10.19(VDATA_IN10)
HDMI_D11: R289.1(P1) U10.18(VDATA_IN11)
HDMI_D12: R290.1(P1) U10.17(VDATA_IN12)
HDMI_D13: R291.1(P1) U10.16(VDATA_IN13)
HDMI_D14: R293.1(P1) U10.15(VDATA_IN14)
HDMI_D15: R294.1(P1) U10.14(VDATA_IN15)
HDMI_D16: R295.1(P1) U10.13(VDATA_IN16)
HDMI_D17: R297.1(P1) U10.11(VDATA_IN17)
HDMI_D18: R298.1(P1) U10.10(VDATA_IN18)
HDMI_D19: R299.1(P1) U10.9(VDATA_IN19)
HDMI_D20: R300.1(P1) U10.8(VDATA_IN20)
HDMI_D21: R301.1(P1) U10.7(VDATA_IN21)
HDMI_D22: R302.1(P1) U10.6(VDATA_IN22)
HDMI_D23: R303.1(P1) U10.4(VDATA_IN23)
HDMI_DE: R312.1(P1) U10.33(DE)
HDMI_EXTSWING: R292.2(P2) U10.56(EXT_SWING)
HDMI_HPLG: R569.2(P2) U10.54(HPD) U11.4(HPD_A)
HDMI_HSYNC: R311.1(P1) U10.34(HSYNC)
HDMI_I2C_SCL: R313.1(P1) U10.1(CSCL)
HDMI_I2C_SDA: R314.1(P1) U10.2(CSDA)
HDMI_I2CSCL: R567.1(P1) U10.49(DSCL) U11.2(SCL_A)
HDMI_I2CSDA: R568.1(P1) U10.48(DSDA) U11.3(SDA_A)
HDMI_INTN: R324.1(P1) R570.1(P1) U10.52(INT)
HDMI_IOVCC: C150.1 C151.1 C152.1 FB12.1 U10.3(IOVCC#3) U10.21(IOVCC#21) U10.46(IOVCC#46)
HDMI_LSOE: R322.1(P1) U11.5(LS_OE)
HDMI_PCLK: R307.1(P1) U10.22(IDCK)
HDMI_TX0+: J10.7(DAT0+) U10.62(TX0+) U11.18(TMDS_D0+)
HDMI_TX0-: J10.9(DAT0-) U10.61(TX0-) U11.17(TMDS_D0-)
HDMI_TX1+: J10.4(DAT1+) U10.65(TX1+) U11.21(TMDS_D1+)
HDMI_TX1-: J10.6(DAT1-) U10.64(TX1-) U11.20(TMDS_D1-)
HDMI_TX2+: J10.1(DAT2+) U10.68(TX2+) U11.23(TMDS_D2+)
HDMI_TX2-: J10.3(DAT2-) U10.67(TX2-) U11.22(TMDS_D2-)
HDMI_VSYNC: R305.1(P1) U10.35(VSYNC)
HDMICONN_CEC: J10.13(CEC) U11.7(CEC_B)
HDMICONN_HPLG: J10.19(HPLG) R304.2(P2) U11.10(HPD_B)
HDMICONN_I2CSCL: J10.15(SCL) R276.1(P1) U11.8(SCL_B)
HDMICONN_I2CSDA: J10.16(SDA) R275.1(P1) U11.9(SDA_B)
JTAG_DETECT: C380.1 J2.8(GND#8) R637.1(P1) U60.3(2A)
JTAG_EMU0: J2.13(EMU0) R71.1(P1) R582.1(P1) U2.C14(EMU0///////GPIO3_7)
JTAG_EMU1: J2.14(EMU1) R70.1(P1) R583.1(P1) U2.B14(EMU1///////GPIO3_8)
JTAG_TCK: R74.2(P2) R75.2(P2) R576.1(P1) U2.A12(TCK)
JTAG_TDI: J2.3(TDI) R577.1(P1) U2.B11(TDI)
JTAG_TDO: J2.7(TDO) R578.1(P1) U2.A11(TDO)
JTAG_TMS: J2.1(TMS) R579.1(P1) U2.C11(TMS)
JTAG_TRSTN: J2.2(TRSTN) R79.2(P2) R580.1(P1) U2.B10(TRSTN)
LCD_DATA0: J7.4 R240.1(P1)
LCD_DATA1: J7.3 R241.1(P1)
LCD_DATA2: J7.6 R245.1(P1)
LCD_DATA3: J7.5 R246.1(P1)
LCD_DATA4: J7.8 R251.1(P1)
LCD_DATA5: J7.7 R252.1(P1)
LCD_DATA6: J8.15 R270.1(P1)
LCD_DATA7: J8.9 R259.1(P1)
LCD_DATA8: J8.11 R262.1(P1)
LCD_DATA9: J8.13 R266.1(P1)
LCD_DATA10: J7.10 R256.1(P1)
LCD_DATA11: J7.16 R267.1(P1)
LCD_DATA12: J7.9 R257.1(P1)
LCD_DATA13: J8.10 R258.1(P1)
LCD_DATA14: J7.12 R260.1(P1)
LCD_DATA15: J8.7 R254.1(P1)
LCD_DATA16: J8.8 R253.1(P1)
LCD_DATA17: J8.5 R248.1(P1)
LCD_DATA18: J8.6 R247.1(P1)
LCD_DATA19: J7.13 R264.1(P1)
LCD_DATA20: J8.3 R243.1(P1)
LCD_DATA21: J8.4 R242.1(P1)
LCD_DATA22: J7.14 R263.1(P1)
LCD_DATA23: J7.11 R261.1(P1)
LCD_DEN: J8.17 R273.1(P1)
LCD_HSYNC: J8.18 R272.1(P1)
LCD_I2C_SCL: J8.14 R265.1(P1)
LCD_I2C_SDA: J7.15 R268.1(P1)
LCD_PCLK: J8.16 R269.1(P1)
LCD_VSYNC: J7.17 R271.1(P1)
LCDA_PIN18: J7.18 R274.2(P2)
LDO_VRTC: C113.1 R557.2(P2) U5.5(OUT)
MCASP0_ACLKR: J6.17 R218.1(P1)
MCASP0_ACLKX: J6.1 R194.2(P2)
MCASP0_AHCLKR: J6.13 R211.2(P2)
MCASP0_AHCLKX: J6.27 R234.1(P1)
MCASP0_AXR0: J6.7 R203.2(P2)
MCASP0_AXR1: J6.23 R227.1(P1)
MCASP0_FSR: J6.21 R224.1(P1)
MCASP0_FSX: J6.5 R199.2(P2)
MMC2_CLK: R485.1(P1) U28.13(CLKB1)
MMC2_CMD: R486.1(P1) U28.12(CMDB1)
MMC2_D0: R487.1(P1) U28.14(DAT0B1)
MMC2_D1: R488.1(P1) U28.15(DAT1B1)
MMC2_D2: R489.1(P1) U28.8(DAT2B1)
MMC2_D3: R490.1(P1) U28.10(DAT3B1)
MMC2_SDIO_SEL: R515.1(P1) R516.2(P2) U28.24(SEL)
MMC_CD: J13.15(CD) R378.1(P1) R380.1(P1) U21.3(IO1)
MMC_CLK: J13.5(#5_MMC+/MMCM/RSMMC/MMC/SD) J13.20(#5_MINISD) R398.1(P1) U19.1(IO1)
MMC_CMD: J13.2(#2_MMC+/MMCM/RSMMC/MMC/SD) J13.17(#2_MINISD) R366.1(P1) R397.1(P1) U19.7(IO5)
MMC_D0: J13.7(#7_MMC+/MMCM/RSMMC/MMC/SD) J13.22(#7_MINISD) R367.1(P1) R399.1(P1) U19.2(IO2)
MMC_D1: J13.8(#8_MMC+/MMCM/SD) J13.23(#8_MINISD) R368.1(P1) R400.1(P1) U19.3(IO3)
MMC_D2: J13.9(#9_MMC+/MMCM/SD) J13.24(#9_MINISD) R369.1(P1) R401.1(P1) U19.6(IO4)
MMC_D3: J13.1(#1_MMC+/MMCM/RSMMC/MMC/SD) J13.16(#1_MINISD) R365.1(P1) R396.1(P1) U19.8(IO6)
MMC_D4: J13.10(#10_MMC+/MMCM) R370.1(P1) U20.1(IO1)
MMC_D5: J13.11(#11_MMC+/MMCM) R371.1(P1) U20.2(IO2)
MMC_D6: J13.12(#12_MMC+/MMCM) R372.1(P1) U20.7(IO5)
MMC_D7: J13.13(#13_MMC+/MMCM) R373.1(P1) U20.8(IO6)
MMC_WP: J13.14(SD_WP) R379.1(P1) U21.5(IO2)
MVRK_GPIO1_D0: J16.2 R437.1(P1)
MVRK_GPIO1_D1: J16.4 R439.1(P1)
MVRK_GPIO1_D2: J16.6 R440.1(P1)
MVRK_GPIO1_D3: J16.8 R441.1(P1)
MVRK_GPIO1_D4: J16.10 R442.1(P1)
MVRK_GPIO1_D5: J16.12 R444.1(P1)
MVRK_GPIO1_D6: J16.14 R446.1(P1)
MVRK_GPIO1_D7: J16.16 R447.1(P1)
MVRK_GPIO1_LATCHEN: J16.20 R450.1(P1)
MVRK_I2C_SCL: J16.11 R443.2(P2)
MVRK_I2C_SDA: J16.13 R445.2(P2)
MVRK_SPI_CS: J16.23 R452.2(P2)
MVRK_SPI_SCLK: J16.17 R448.2(P2)
MVRK_SPI_SIMO: J16.21 R451.2(P2)
MVRK_SPI_SOMI: J16.19 R449.2(P2)
MVRK_UART_RXD: J16.3 R438.2(P2)
MVRK_UART_TXD: J16.1 R436.2(P2)
NAND_ADVN_ALE: R137.1(P1) U9.17(ALE)
NAND_BE0N_CLE: R136.1(P1) U9.16(CLE)
NAND_CSN: R132.1(P1) R135.1(P1) U9.9(\\C\E\)
NAND_D0: R140.1(P1) U9.29(I/O0)
NAND_D1: R141.1(P1) U9.30(I/O1)
NAND_D2: R142.1(P1) U9.31(I/O2)
NAND_D3: R143.1(P1) U9.32(I/O3)
NAND_D4: R144.1(P1) U9.41(I/O4)
NAND_D5: R145.1(P1) U9.42(I/O5)
NAND_D6: R146.1(P1) U9.43(I/O6)
NAND_D7: R147.1(P1) U9.44(I/O7)
NAND_D8: R148.1(P1) U9.26(NC_IO8)
NAND_D9: R149.1(P1) U9.27(NC_IO9)
NAND_D10: R150.1(P1) U9.28(NC_IO10)
NAND_D11: R151.1(P1) U9.33(NC_IO11)
NAND_D12: R152.1(P1) U9.40(NC_IO12)
NAND_D13: R153.1(P1) U9.45(NC_IO13)
NAND_D14: R154.1(P1) U9.46(NC_IO14)
NAND_D15: R155.1(P1) U9.47(NC_IO15)
NAND_OEN: R134.1(P1) U9.8(\\R\E)
NAND_WAIT: R131.1(P1) R133.1(P1) U9.7(R/\B\)
NAND_WEN: R138.1(P1) U9.18(\\W\E)
NAND_WPN: R130.1(P1) R139.1(P1) U9.19(\\W\P)
PB_INTERRUPT: C118.1 R113.2(P2) R156.1(P1) R560.1(P1)
PHY_LED_10/100N: C207.1 U25.26(LED_LINK10_100)
PHY_LED_1000N: C206.1 R392.1 R431.2(P2) U25.24(LED_LINK1000)
PHY_LED_ACTN: C205.1 R390.1 R435.2(P2) U25.23(LED_ACT)
PHY_PPS/GPIO: R395.1(P1) U25.22(PPS)
PM_ALERT: J17.4 R455.1(P1) U27.3(ALERT) U32.3(ALERT)
PM_VDDAADCN: C372.2 J27.2 R501.3(SENS1)
PM_VDDAADCP: C372.1 J27.1 R501.4(SENS2)
PM_VDDCOREN: C353.2 R32.4(SENS2) U27.9(VIN-)
PM_VDDCOREP: C353.1 R32.3(SENS1) U27.10(VIN+)
PM_VDDMPUN: C356.2 R46.4(SENS2) U32.9(VIN-)
PM_VDDMPUP: C356.1 R46.3(SENS1) U32.10(VIN+)
PM_VDDSDDRMEMN: C378.2 J41.2 R513.4(SENS2)
PM_VDDSDDRMEMP: C378.1 J41.1 R513.3(SENS1)
PM_VDDSDDRN: C361.2 J20.2 R508.4(SENS2)
PM_VDDSDDRP: C361.1 J20.1 R508.3(SENS1)
PM_VDDSHV1N: C363.2 J26.2 R493.3(SENS1)
PM_VDDSHV1P: C363.1 J26.1 R493.4(SENS2)
PM_VDDSHV2N: C374.2 J38.2 R545.3(SENS1)
PM_VDDSHV2P: C374.1 J38.1 R545.4(SENS2)
PM_VDDSHV3N: C375.2 J39.2 R546.3(SENS1)
PM_VDDSHV3P: C375.1 J39.1 R546.4(SENS2)
PM_VDDSHV4N: C365.2 J30.2 R494.3(SENS1)
PM_VDDSHV4P: C365.1 J30.1 R494.4(SENS2)
PM_VDDSHV5N: C367.2 J32.2 R495.3(SENS1)
PM_VDDSHV5P: C367.1 J32.1 R495.4(SENS2)
PM_VDDSHV6N: C369.2 J34.2 R496.3(SENS1)
PM_VDDSHV6P: C369.1 J34.1 R496.4(SENS2)
PM_VDDSN: C370.2 J21.2 R498.3(SENS1)
PM_VDDSOSCN: C373.2 J29.2 R506.3(SENS1)
PM_VDDSOSCP: C373.1 J29.1 R506.4(SENS2)
PM_VDDSP: C370.1 J21.1 R498.4(SENS2)
PM_VDDSRTCN: C379.2 J35.2 R505.3(SENS1)
PM_VDDSRTCP: C379.1 J35.1 R505.4(SENS2)
PM_VPLLCRLCDN: C371.2 J24.2 R503.3(SENS1)
PM_VPLLCRLCDP: C371.1 J24.1 R503.4(SENS2)
PM_VPLLDDRN: C368.2 J33.2 R507.4(SENS2)
PM_VPLLDDRP: C368.1 J33.1 R507.3(SENS1)
PM_VPLLMPUN: C355.2 J22.2 R497.4(SENS2)
PM_VPLLMPUP: C355.1 J22.1 R497.3(SENS1)
PM_VSRAMCOREN: C362.2 J23.2 R500.4(SENS2)
PM_VSRAMCOREP: C362.1 J23.1 R500.3(SENS1)
PM_VSRAMMPUN: C360.2 J25.2 R499.4(SENS2)
PM_VSRAMMPUP: C360.1 J25.1 R499.3(SENS1)
PM_VUSB1_8VN: C364.2 J28.2 R502.4(SENS2)
PM_VUSB1_8VP: C364.1 J28.1 R502.3(SENS1)
PM_VUSB3_3VN: C366.2 J31.2 R504.4(SENS2)
PM_VUSB3_3VP: C366.1 J31.1 R504.3(SENS1)
PMIC_DELAYEDRTCPORZ: R3.1(P1) U1.2(B)
PMIC_GPIO: C114.1 R3.2(P2) R54.1(P1) R57.2(P2) R69.1(P1)
PMIC_I2C_SCL: R55.1(P1) R551.1(P1) U4.9(SCL_SCK)
PMIC_I2C_SDA: R56.1(P1) R550.1(P1) U4.8(SDA_SDI)
PMIC_INTN: R61.1(P1) R66.1(P1) R67.1(P1) U4.45(INT1)
PMIC_PWR_EN: R65.2(P2) R178.1(P1) R478.2(P2) R556.2(P2) U2.C6(PMIC_POWER_EN)
PMIC_PWRHOLD: R556.1(P1) R628.1(P1) U4.1(PWRHOLD)
PMIC_RESETOUTN: R2.2(P2) U4.40(NRESPWRON) U63.3(M\R\)
PMIC_SLEEP: R62.1(P1) R65.1(P1) U4.37(SLEEP)
PMICSR_I2C_SCL: R58.1(P1) U4.11(SCLSR_EN1)
PMICSR_I2C_SDA: R59.1(P1) U4.10(SDASR_EN2)
PWR_SMPS1: L2.1 U4.35(SW1)
PWR_SMPS1_FB: R561.2(P2) R562.2(P2) U4.32(VFB1)
PWR_SMPS2: L3.1 U4.42(SW2)
PWR_SMPS3: L8.1 U4.31(SW3)
PWR_SWIO: L4.1 U4.14(SWIO)
PWR_VAUX1: C109.1 R474.1(P1) U4.46(VAUX1)
PWR_VAUX2: C110.1 R475.1(P1) U4.48(VAUX2)
PWR_VAUX33: C108.1 R463.2(P2) R466.1(P1) R628.2(P2) U4.4(VAUX33)
PWR_VDAC: C101.1 R471.1(P1) U4.22(VDAC)
PWR_VDD1_SMPS: C237.1 L2.2 R469.2(P2) R562.1(P1)
PWR_VDD2_SMPS: C239.1 L3.2 R468.2(P2) U4.44(VFB2)
PWR_VDD3_SMPS: L8.2 R470.2(P2) U4.30(VFB3)
PWR_VDDIO: R465.2(P2) R466.2(P2) U4.12(VDDIO)
PWR_VDIG1: C104.1 R464.2(P2) U4.7(VDIG1)
PWR_VDIG2: C103.1 R476.2(P2) U4.5(VDIG2)
PWR_VIO_SMPS: C241.1 L4.2 R465.1(P1) R467.2(P2) U4.16(VFBIO)
PWR_VMMC: C107.1 R477.2(P2) U4.2(VMMC)
PWR_VPLL: C102.1 R473.1(P1) U4.24(VPLL)
PWRMON_I2CSCL: J17.1 R453.1(P1) U27.5(SCL) U32.5(SCL)
PWRMON_I2CSDA: J17.2 R454.1(P1) U27.4(SDA) U32.4(SDA)
RS232_CTS: J12.8 U18.8(RIN2)
RS232_RTS: J12.7 U18.7(DOUT2)
RS232_RXD: J12.2 U18.13(RIN1)
RS232_TXD: J12.3 U18.14(DOUT1)
RTCK: J2.9(TCKRTN) R74.1(P1)
SDIO_GPMC_A1: R196.2(P2) U28.18(DAT0B0)
SDIO_GPMC_A2: R198.2(P2) U28.16(DAT1B0)
SDIO_GPMC_A3: R202.2(P2) U28.23(DAT2B0)
SDIO_GPMC_BE1N: R186.2(P2) U28.22(DAT3B0)
SDIO_GPMC_CLK: R181.2(P2) U28.19(CLKB0)
SDIO_GPMC_CS3N: R187.2(P2) U28.20(CMDB0)
SYS_RESETN: J3.26 R6.1(P1) R10.2(P2) R306.1(P1) R517.2(P2) U2.A10(WARMRSTN) U10.51(RESETN) U26.2(A)
SYS_WARMRESETN: C117.1 J4.11 R10.1(P1) R575.1(P1) SW2.3 SW2.4 U48.1
TCK: J2.11(TCK) R75.1(P1)
TSC_CLK: J9.5 R250.1(P1)
TSC_GIO0: J9.1 TP38.1
TSC_GIO1: J9.3 TP39.1
TSC_GIO2: J9.8 R255.1(P1)
TSC_I2CSCL: J9.4 R244.1(P1)
TSC_I2CSDA: J9.6 R249.1(P1)
TSC_RSV0: J9.7 TP40.1
TSC_RSV1_VREF: J9.9 TP41.1
UART0_CTSN: R364.1(P1) U18.9(ROUT2)
UART0_RTSN: R362.1(P1) U18.10(DIN2)
UART0_RXD: R363.1(P1) U18.12(ROUT1)
UART0_TXD: R361.1(P1) U18.11(DIN1)
USB0_CONN_DM: J14.2(DM) L5.3 U23.2(D-)
USB0_CONN_DP: J14.3(DP) L5.4 U23.1(D+)
USB0_CONN_ID: J14.4(ID) R402.1(P1)
USB0_DM: L5.2 U2.N18(USB0_DM)
USB0_DP: L5.1 U2.N17(USB0_DP)
USB0_ID: R381.2(P2) R402.2(P2) R571.1(P1) U2.P16(USB0_ID) U23.3(ID)
USB0_MEAS_IDN: Q5.G(GATE) R565.1(P1) R566.1(P1)
USB0_OVRCURN: R382.2(P2) R384.2(P2) U22.5(O\C\)
USB1_CONN_DM: J18.2(DM) L6.3 U30.2(D-)
USB1_CONN_DP: J18.3(DP) L6.4 U30.1(D+)
USB1_DM: L6.2 U2.R18(USB1_DM)
USB1_DP: L6.1 U2.R17(USB1_DP)
USB1_ID: R385.2(P2) U2.P17(USB1_ID) U30.3(ID)
USB1_OVRCURN: R410.2(P2) R412.2(P2) U29.5(O\C\)
USB5V_FB: R520.1(P1) R521.2(P2) U24.E3(FB)
VADDL_PHY: C198.1 C199.1 C200.1 C201.1 FB16.1 U25.8(AVDDL#8) U25.13(AVDDL#13) U25.19(AVDDL#19) U25.44(AVDDL#44)
VAUX1: J19.16 R474.2(P2) R502.1(I1)
VAUX2: C209.1 FB2.2 FB6.2 FB8.2 FB20.2 J4.1 J19.17 R68.2(P2) R475.2(P2)
VAUX33: C20.1 C266.1 J19.18 R463.1(P1) R504.1(I1) R594.2(P2) R595.2(P2) U62.10(VIN) U64.1(VCCA)
VBCKUPBAT: BT1.1(POS) TP26.1 U4.27(VBACKUP)
VCOM_BAT: C161.1 C171.1 C172.1 J11.5 J11.7 R359.2 U17.4(OUT)
VCOM_BATEN: R358.1(P1) U17.1(EN)
VCOM_BATFB: C171.2 R359.1 R360.2(P2) U17.5(FB)
VDAC: J19.14 R471.2(P2) R498.2(I2)
VDIG1: FB1.2 FB3.2 FB7.2 FB21.2 J19.11 R464.1(P1) R472.2(P2)
VDIG2: J19.12 R476.1(P1) R497.1(I1) R499.1(I1) R500.1(I1) R503.2(I2) R506.2(I2) R507.1(I1)
VETH_AVDD_3_3: C194.1 C248.1 FB15.2 U25.16(AVDD33)
VETH_LX: L7.2 U25.3(LX)
VETH_VDDIO: C193.1 R388.1(P1) R389.2(P2) R407.1(P1) R408.2(P2) U25.29(VDDIO_REG)
VIO_SMPS: J19.9 R467.1(P1) R508.1(I1) R513.1(I1) R542.1(P1)
VMMC: FB4.2 FB5.2 J19.13 R477.1(P1)
VPLL: FB9.2 J19.15 R473.2(P2)
VPMIC_VRTC: C97.1 R53.1(P1) R60.2(P2) U4.29(VRTC)
VPP: C381.1 R639.2(P2) U2.M5(VPP)
VPP_CONN: J42.2 R639.1(P1)
VPWRIN_FUSED: D2.1(CATHODE) F1.2 SW1.1
VPWRIN_JCK: D1.2(ANODE) J1.1
VPWRIN_PREFUSE: D1.1(CATHODE) F1.1
VREFP_ADC: C9.1 C10.1 C11.1 C12.1 R30.2(P2) U2.B9(VREFP)
VRTC: C1.1 C91.1 C111.1 J19.3 R53.2(P2) R54.2(P2) R393.2(P2) R505.2(I2) R557.1(P1) U1.1(A) U1.5(VCC) U6.1(2A) U6.2(2B) U6.8(VCC)
VTT_EN: R595.1(P1) R632.1(P1) U62.7(EN)
VTT_EN_1_5V: R635.1(P1) U64.4(B)
VTT_EN_3_3V: R632.2(P2) R636.2(P2) U64.3(A)
VUSB_FTDI: C315.1 D11.2(ANODE) FB22.2 R591.2(P2)
VUSB_JTAG: C314.1 FB22.1 J40.1(VBUS) U57.1(VCC)
VUSB_VBUS0: C183.1 C262.1 J14.1(VBUS) J36.1 R563.2(P2) U22.6(OUT#6) U22.7(OUT#7) U22.8(OUT#8) U23.6(VBUS)
VUSB_VBUS1: C186.1 C265.1 J18.1(VBUS) J37.1 R558.1(P1) R564.2(P2) U29.6(OUT#6) U29.7(OUT#7) U29.8(OUT#8) U30.6(VBUS)
XTIN: C332.1 U58.2(XTIN) Y4.1
XTOUT: C333.1 U58.3(XTOUT) Y4.2
N17759: C5.1 R7.1(P1) R8.2(P2) Y2.1
N120395: D3.2(ANODE) R50.1(P1)
N124510: J2.4(TDIS) R73.2(P2)
N150689: C3.2 R5.2(P2) Y1.1
N194366: C9.2 C10.2 C13.1 C14.1 R51.1(P1) U2.A9(VREFN)
N16794306: J15.D1 R390.2
N16794816: J15.D4 R392.2
N16958667: R308.2(P2) U10.69(IO_SEL)
N17034041: R114.2(P2) SW3.1
N17034069: R115.2(P2) SW3.2
N17034107: R116.2(P2) SW3.3
N17034117: R117.2(P2) SW3.4
N17034161: R118.2(P2) SW3.5
N17034171: R119.2(P2) SW3.6
N17034215: R120.2(P2) SW3.7
N17034225: R121.2(P2) SW3.8
N17059155: R325.2(P2) U10.36(SPDIF)
N17084504: D8.1(CATHODE) R277.2(P2)
N17084966: R326.2(P2) U10.72(CI2CA)
N17107785: C98.1 U4.18(VREF)
N17298950: C179.1 U18.6(V-)
N17298952: C177.1 U18.2(V+)
N17298960: C176.2 U18.3(C1-)
N17298962: C178.1 U18.4(C2+)
N17298964: C178.2 U18.5(C2-)
N17298974: C176.1 U18.1(C1+)
N17338171: R354.2(P2) U16.4(1A1)
N17338175: R355.2(P2) U16.5(1A2)
N17338916: R356.2(P2) U16.6(2A1)
N17338919: R357.2(P2) U16.7(2A2)
N17339217: R347.2(P2) U14.5(1A2)
N17339337: R348.2(P2) U14.6(2A1)
N17339991: R346.2(P2) U14.4(1A1)
N17340025: R335.2(P2) U13.6(2A1)
N17340083: R336.2(P2) U13.7(2A2)
N17342017: R350.2(P2) U15.4(1A1)
N17342025: R351.2(P2) U15.5(1A2)
N17342093: R352.2(P2) U15.7(2A2)
N17345501: R122.2(P2) SW4.1
N17345515: R123.2(P2) SW4.2
N17345519: R124.2(P2) SW4.3
N17345529: R125.2(P2) SW4.4
N17345551: R126.2(P2) SW4.5
N17345553: R127.2(P2) SW4.6
N17345567: R128.2(P2) SW4.7
N17345577: R129.2(P2) SW4.8
N17563948: Q1.G(GATE) R84.1(P1) R85.1(P1) R86.2(P2) R509.1(P1)
N17563994: D4.2(ANODE) R80.1(P1)
N17563997: D4.1(CATHODE) Q1.D(DRAIN)
N17564510: D5.1(CATHODE) Q2.D(DRAIN)
N17564514: D5.2(ANODE) R81.1(P1)
N17564644: D6.1(CATHODE) Q3.D(DRAIN)
N17564648: D6.2(ANODE) R82.1(P1)
N17564780: D7.1(CATHODE) Q4.D(DRAIN)
N17564784: D7.2(ANODE) R83.1(P1)
N17564892: Q2.G(GATE) R87.1(P1) R88.1(P1) R93.2(P2) R510.1(P1)
N17564904: Q3.G(GATE) R89.1(P1) R90.1(P1) R95.2(P2) R511.1(P1)
N17564916: Q4.G(GATE) R91.1(P1) R92.1(P1) R94.2(P2) R512.1(P1)
N17601395: R349.2(P2) R492.2(P2) U14.7(2A2)
N17618848: C212.2 U25.6(XTLO) Y3.1
N17618850: C204.2 U25.7(XTLI) Y3.2
N17618867: TP47.1 U25.45(SIN)
N17619022: TP49.1 U25.42(SON)
N17619024: TP48.1 U25.43(SOP)
N17619221: R393.1(P1) R405.1(P1) R479.1(P1) U25.40(WOL_INT)
N17619435: R395.2(P2) TP50.1
N17619707: R394.2(P2) U25.41(SD)
N17619739: TP46.1 U25.46(SIP)
N17684279: J8.12 R239.1(P1)
N17684406: R63.1(P1) R629.1(P1) SW6.3 SW6.4 U4.33(PWRON)
N17710761: R22.2(P2) U2.J3(DDR_VTP)
N18082443: R328.2(P2) U13.4(1A1)
N18136628: R72.1(P1) U7.7(WP)
N18365790: R57.1(P1) U4.39(GPIO_CKSYNC)
N18368859: R69.2(P2) U6.7(2Y)
N19410176: R518.1(P1) U15.6(2A1)
N19410226: R519.1(P1) U13.12(1B2)
N19440113: L9.1 U24.B1(L1#B1) U24.B2(L1#B2)
N19440133: L9.2 U24.D1(L2#D1) U24.D2(L2#D2)
N19440219: C264.1 U24.A3(VINA) U24.B3(VINA1) U24.C4(P\S\) U24.D4(VSEL)
N19490589: TP24.1 U2.A3(RESERVED)
N19558182: R544.1(P1) U32.2(A0)
N19577113: R64.1(P1) U4.26(BOOT0)
N19577116: R60.1(P1) U4.19(BOOT1)
N21001557: R112.2(P2) R156.2(P2) SW5.1 SW5.2
N21001559: R559.1(P1) R560.2(P2) SW5.3 SW5.4 U49.1
N21339295: Q5.D(DRAIN) R23.2(P2)
N21540235: R585.1(P1) U58.14(RESET#) U60.4(2Y)
N21540301: D11.1(CATHODE) R586.2
N21540351: R587.2(P2) R588.1(P1) U61.4(DO)
N21540405: R586.1 U58.60(PWREN#)
N21540429: TP52.1 U58.36(SUSPEND#)
N21815253: C313.1 U54.4(NR)
N21825062: R590.2(P2) R591.1(P1) R627.2(P2) U58.59(BCBUS7)
N21837772: R592.2(P2) U58.32(ACBUS5)
N21889047: R593.2(P2) U58.28(ACBUS2)
N22489222: R594.1(P1) U62.9(PGOOD)
N22502363: C337.1 R603.1(P1) U62.5(VOSNS)
N22504661: C341.1 R596.2(P2) R597.1(P1) U62.1(REFIN)
N22518686: C352.1 R624.1(P1) R625.1(P1)
N22552028: R9.1(P1) R634.1(P1) U63.1(R\E\S\E\T\)
N22597176: TP53.1 U4.38(CLK32KOUT)
N23180701: C7.1 U63.4(CT)
N23328497: R572.2(P2) U33.H8(ZQ)
N23340381: R573.2(P2) U34.H8(ZQ)
N23425673: J42.4 R638.1(P1)

Pads without a net: J2 6; J3 4 6 8 10 12 14 16 18 20 22; J4 2 3 4 5 6 9 10 13 14 15 16 17 18 20 22 24 27; J5 5 7 9 40; J10 14; J11 10 12 14 16 17 21 23 25 27 29 31 33 36 38 40 41 43 44 45 46 49 51 53 55 57 59 61 65 67 69 71 73 74 75 78 79 80 81 82 84 85 86 88 90 91 93 94 96 98 99 100; J12 1 4 6 9; J13 25 26; J15 M1 M2; J16 7 9 18 22 24 25 26; J17 5; J40 4; R566 2; SW1 3; U4 20 21 25; U5 4; U6 3; U9 1 2 3 4 5 6 10 11 14 15 20 21 22 23 24 35 38; U12 4; U13 5; U15 11; U19 4 9; U20 3 4 6 9; U21 2; U23 5; U26 1; U30 5; U33 A3 A7 F1 F9 H1 H9; U34 A3 A7 F1 F9 H1 H9; U57 2; U58 22 24 27 29 33 34 38 39 40 41 43 44 45 46 48 52 53 54 55 57 58; Y1 2 3; Y2 2 4

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 2733 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 186 vias
v3: diameter 0.762, hole 0.457, TOP to BOTTOM, 18 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 1648.5
  TOP w0.102: v1(76.75,79.16) 76.31,79.16 76.09,78.93 72.09,78.93 71.61,78.45 71.61,78.09 71.71,78 v1(71.71,77.13) 72.21,77.63 74.07,77.63 74.37,77.93 77.24,77.93 v2(77.51,78.2)
  TOP w0.121: v1(154.6,145.96) 154.89,146.25 U24.E4 ; v1(38.29,59.07) 38.29,59.51 38.31,59.53 38.31,59.65 38.44,59.78 40.7,59.78 41.16,60.24 41.16,62.09 40.83,62.42 37.15,62.42 36.88,62.15 v1(36.88,59.59) ; U24.C1 U24.C2 U24.C3 U24.D3 ; v1(156.25,145.58) 156.39,145.73 U24.B4 ; 46.62,112.98 49.22,112.98 49.58,113.35 v1(50.02,113.35) 50.47,113.35 50.49,113.32 60.96,113.32 61.45,113.81 81.97,113.81 v1(82.31,113.47) 82.7,113.08 85.78,113.08 85.95,113.25 87.34,113.25 87.6,113 87.6,112.63 87.34,112.37 86.37,112.37 86.2,112.2 v1(82.41,112.2) 81.73,112.2 80.63,113.3 61.65,113.3 61.17,112.83 51.81,112.83 51.45,112.47 41.22,112.47 v1(40.58,113.12) 41.06,113.6 46,113.6 46.62,112.98 ; 50.46,114.42 50.28,114.25 49.92,114.25 49.66,114.51 49.66,114.88 50,115.21 v1(50.67,115.21) 56.79,115.21 57.34,114.67 58.79,114.67 v1(59.28,115.16) 82.63,115.16 83.17,115.7 85.38,115.7 85.88,116.19 v1(86.6,116.19) 86.91,115.88 86.91,115.58 86.44,115.11 83.28,115.11 82.84,114.67 60.72,114.67 v1(60.48,114.43) 60.22,114.17 57.13,114.17 56.88,114.42 50.46,114.42
  TOP w0.203: v1(89.72,100.82) 89.74,100.81 D10.2 ; C111.2 87.43,23.02 87.67,22.78 U6.4 ; U4.15 90.85,32.29 v3(90.72,32.42) ; U4.34 88.05,34.64 U4.PPAD ; U4.17 93.39,33.09 v1(93.51,33.22) ; D9.2 v1(94.91,96.18) ; U4.43 87.98,33.49 v3(88.18,33.69)
  TOP w0.254: v1(10.6,77.16) 10.46,77.02 U58.11 ; v1(66.25,144.59) 65.73,144.06 U21.4 ; U58.35 v1(21.85,75.52) ; U58.5 v1(10.58,80.02) ; J10.11 v1(147.16,7.03) ; C318.1 v1(4.74,53.12) ; U58.13 10.49,76.02 v1(10.63,75.88) ; U6.5 90.7,22.78 v1(90.46,23.02) 90.72,23.28 U6.6 ; J10.17 144.16,7.2 144.21,7.15 v1(144.21,6.97) ; J10.5 v1(150.16,7.07) ; U28.11 v1(20.24,107.87) ; J11.18 4.74,114.85 v1(4.36,115.23) ; J10.8 v1(148.66,7.04) ; U58.47 v1(19.39,81.52) ; U58.10 v1(8.05,77.52) ; U58.15 v1(8.17,75.02) ; U60.2 v1(10.45,55.51) ; v1(79.98,62.24) U34.F2 ; J11.42 v1(4.61,122.47) ; U19.5 v1(60.11,144.06) ; U58.25 v1(15.27,71.33) ; U58.1 v1(9.32,82.75) ; v1(4.36,116.12) 6.07,116.12 ; U32.1 v1(61.86,36.72) ; U24.C1 v1(155.99,148.12) ; U58.51 v1(17.77,85.2) ; v1(23.91,111.54) 23.77,111.4 U28.2 ; J10.2 v1(151.66,7.08) ; U57.4 v1(9.3,100.53) ; U32.7 v1(65.77,34.65)
  TOP w0.305: v1(24.68,120.94) 24.94,120.68 U13.8 ; v1(7.66,111.42) 7.28,111.04 6.07,111.04 ; U15.14 21.59,136.48 v1(21.88,136.18) 21.53,135.83 U15.15 ; U14.14 21.59,123.78 v1(21.88,123.48) 21.53,123.13 U14.15 ; v1(21.88,120.94) 21.62,120.68 U13.9 ; U14.8 24.94,127.03 v1(24.68,127.29) ; U2.A18 77.89,92.11 v2(77.89,92.24) ; U10.55 v1(136.06,28.49) ; v1(24.68,139.99) 24.94,139.73 U15.8 ; v1(21.88,133.64) 21.62,133.38 U16.9 ; U9.13 149.25,97.82 v1(149.52,98.08) ; U15.9 21.62,139.73 v1(21.88,139.99) ; U10.70 144.13,29.2 v1(144.31,29.37) ; v1(4.36,109.38) 4.74,109.77 J11.2 ; J11.60 7.53,128.18 v1(7.66,128.05) ; U16.14 21.59,130.13 v1(21.88,129.83) 21.53,129.48 U16.15 ; U10.63 v1(140.63,29.37) ; v1(137.71,34.69) U10.43 ; U14.9 21.62,127.03 v1(21.88,127.29) ; U16.8 24.94,133.38 v1(24.68,133.64) ; v1(149.52,117.64) 149.26,117.39 U9.36 ; U16.3 27.07,130.13 v1(27.42,129.78) ; v1(154.98,117.51) 154.76,117.3 U9.25 ; U2.A1 v2(77.51,78.2) ; v2(84.2,82.6) U2.J7 ; U10.57 137.63,29.3 v1(137.71,29.37) ; U13.15 21.53,116.78 v1(21.88,117.13) 21.59,117.43 U13.14 ; U2.V1 v2(92.5,78.2) ; U9.48 v1(143.26,117.48) ; v2(81.8,83.4) U2.F8 ; v2(84.2,81.8) U2.J6
  TOP w0.381: C264.2 v1(155.61,142.91) ; v2(88.2,86.6) U2.N11 ; U11.19 v1(142.09,15.35) ; v1(93.78,57.44) U33.F8 ; U13.2 24.96,116.78 v1(24.8,116.62) ; U54.2 v1(18.83,93.15) ; U2.H10 v2(83.4,85.8) U2.G11 ; C329.1 v1(6.51,75.83) ; v1(12.23,112.56) 12.48,112.31 J11.9 ; v1(83.98,57.44) U34.A8 ; v1(159.42,145.07) 159.68,145.33 C187.2 ; 97.07,87.79 v1(97.7,88.43) ; J11.97 15.4,143.42 v1(15.66,143.17) 15.28,142.79 J11.95 ; R381.1 133.57,162.7 133.51,162.76 U23.4 132.87,162.95 133.07,163.15 133.07,163.62 133.01,163.68 C183.2 133.13,163.84 v1(133.9,163.84) ; v1(27.47,123.61) 27.3,123.78 U14.3 ; U61.7 v1(11.21,96.3) 11.21,97.19 C334.2 ; U55.3 v1(8.05,51.71) ; U20.5 v1(71.92,151.29) ; J13.28 v1(39.1,163.69) ; v1(93.78,62.24) U33.F2 ; U12.2 148.63,20.33 148.56,20.4 148.56,20.67 v1(148.5,20.74) ; v1(76.78,63.84) U34.J1 ; v2(86.6,85.8) U2.L10 ; U30.4 v1(149.07,161.89) 149.2,162.03 R385.1 ; v1(49.31,85) C28.2 ; U33.N9 v1(88.18,56.64) 88.18,54.65 C227.2 ; v1(96.18,63.84) U33.D1 ; v1(79.18,57.44) U34.F8 ; U63.2 65.44,101 65.32,100.88 v1(65.25,100.88) ; C333.2 v1(2.2,85.28) ; v2(87.4,85.8) U2.M10 ; v1(91.38,56.64) U33.J9 ; J14.5 v1(129.42,164.8) ; J2.12 v1(31.28,90.46) ; U61.5 v1(13.75,96.25) ; U2.M8 v2(87.4,84.2) U2.M9 ; v1(15.91,110.27) 15.79,110.4 J11.3 ; C114.2 v1(96.68,22.26) ; v1(55.03,104.05) 55.6,104.05 55.63,104.03 55.94,104.03 56.18,103.78 U1.3 ; v1(149.07,162.91) 148.88,163.11 148.37,163.11 ; U5.2 v1(84.11,22.52) ; U26.3 23.39,60.86 22.76,60.86 v1(22.39,60.49) ; C312.2 v1(19.83,90.5) ; v1(155.99,149.64) v1(155.99,148.88) v1(155.99,148.12) ; v1(81.58,56.64) U34.D9 ; J11.64 4.99,132.63 v1(4.61,132.24) ; v1(88.18,63.84) U33.N1 ; v1(52.11,66.71) 52.36,66.46 52.36,65.7 ; C175.2 v1(111.29,25.51) ; R411.1 v1(38.3,55.54) ; v1(73.58,56.64) U34.N9 ; v2(82.6,87.4) U2.G12 ; v1(96.98,56.64) U33.C9 ; R413.1 v1(38.3,54.27) ; U11.14 143.46,12.1 v1(142.15,12.1) ; J13.27 v1(67.4,163.92) ; v1(81.58,63.84) U34.D1 ; R569.1 131.71,27.72 v1(131.65,27.72) ; U2.H7 v2(84.2,82.6) ; U2.N14 v2(87.4,89) U2.M14 ; v2(85.8,86.6) U2.K11 ; v1(78.02,31.79) 76.97,31.79 76.75,31.56 C239.2 ; v1(12.36,122.08) 12.61,121.83 J11.39 ; R426.1 v1(38.3,51.73) ; J2.10 v1(27.6,91.73) ; v1(82.66,54.32) 83.53,54.32 C226.2 ; C332.2 v1(2.2,86.07) ; U2.L13 v2(86.6,87.4) U2.L12 ; J11.19 v1(12.23,115.48) ; U2.J11 v2(84.2,86.6) ; U33.B2 v1(97.78,62.24) ; U33.B1 v1(97.78,63.84) ; 29.41,87.92 v1(31.41,87.92) ; U2.G9 v2(83.4,84.2) U2.H9 ; C111.2 v1(87.03,22.26) ; U34.B1 v1(83.18,63.84) ; v2(87.4,87.4) U2.M12 ; v1(96.18,57.44) U33.D8 ; v1(82.38,56.64) U34.C9 ; C263.2 158.39,145.49 158.15,145.25 v1(158.15,144.44) ; v1(71.71,77.13) 71.09,77.13 R48.1 ; J13.6 58.88,147.27 58.71,147.1 v1(58.33,147.1) 58.03,147.41 J13.18 ; J11.87 v1(12.48,140.25) ; J40.5 v1(5.42,98.18) ; v1(75.18,56.64) U34.L9 ; 14.07,121.2 12.74,121.2 v1(12.36,120.81) 12.61,120.56 J11.35 ; 14.07,138.98 v1(12.48,138.98) ; U11.6 v1(136.11,15.35) ; v1(89.78,56.64) U33.L9 ; C15.2 v1(27.85,107.35) ; v2(83.4,83.4) U2.H8 ; C313.2 21.38,95.93 v1(21.38,95.27) ; C323.1 v1(7.28,79.54) ; C137.2 v1(141.64,88.05) ; v2(85.8,82.6) U2.K7 ; v2(84.2,85.8) U2.J10 ; J11.47 v1(12.36,124.37) ; C311.2 v1(19.83,100.66) ; v2(87.4,81.8) U2.M6 ; R592.1 18.71,67.86 v1(19.6,67.86) ; J11.92 v1(4.36,141.52) ; U2.H6 v2(84.2,81.8) ; 29.41,85.38 v1(27.47,85.38) ; v1(75.18,63.84) U34.L1 ; v2(85.8,85.8) U2.K10 ; v2(87.4,82.6) U2.M7 ; v2(84.2,83.4) U2.J8 ; J11.63 v1(12.36,132.63) ; v1(81.58,57.44) U34.D8 ; U33.A1 v1(98.58,63.84) ; v1(83.18,57.44) U34.B8 ; v2(82.6,83.4) U2.G8 ; U34.A1 v1(83.98,63.84) ; R419.1 v1(38.3,53) ; v1(98.58,57.44) U33.A8 ; J11.77 v1(12.48,137.07) ; v1(76.78,56.64) U34.J9 ; v2(88.2,82.6) U2.N7 ; v2(85.8,84.2) U2.K9 ; U34.B2 v1(83.18,62.24) ; v2(86.6,86.6) U2.L11 ; v1(73.58,63.84) U34.N1 ; R414.1 v1(38.3,56.81) ; v1(89.78,63.84) U33.L1 ; v2(84.2,84.2) U2.J9 ; FB14.1 v1(135.73,163.53) ; v1(96.18,56.64) U33.D9 ; v2(83.4,87.4) U2.H12 ; R422.1 v1(38.3,58.08) ; v2(88.2,85.8) U2.N10 ; v1(91.38,63.84) U33.J1 ; v1(97.78,57.44) U33.B8
  TOP w0.508: C107.2 v1(87.03,25.82) ; v1(15.79,152.31) 15.53,152.56 C173.2 ; C159.2 v1(150.53,19.72) ; U22.1 v1(133.51,146.71) ; 27.98,110.53 v1(28.74,110.53) ; v1(95.03,13.88) 95.03,12.61 95.41,12.23 C84.2 ; v1(31.41,62.9) 31.4,62.9 31.4,62.02 C197.2 ; C381.2 96.68,79.16 v1(96.56,79.03) ; v1(129.82,87.2) 129.78,87.16 129.58,87.16 C139.2 ; v1(39.03,46.77) 38.77,47.03 C206.2 ; C112.2 v1(86.02,23.28) ; v1(97.7,13.75) 97.7,12.74 97.19,12.23 C84.2 ; U17.6 v1(6.9,152.69) ; U18.15 113.32,21.75 v1(113.58,21.5) ; C61.2 v1(118.35,136.94) ; C7.2 C6.2 60.36,101.38 60.02,101.04 60.02,100.75 v1(60,100.73) ; v1(29.5,64.43) 29.5,63.65 C256.2 30.39,63.78 v1(30.39,64.43) ; v1(157.77,17.31) 157.77,17.96 C244.2 156.88,18.09 v1(156.88,17.31) ; v1(5.75,50.33) 5.88,50.2 R626.1 ; v1(34.84,165.14) 35.41,165.14 Q1.S ; C88.2 v1(92.63,19.34) ; C84.2 v1(96.31,13.75) ; C234.2 92.75,17.71 v1(92.75,16.61) ; J13.3 51.38,147.46 51.8,147.04 v1(51.85,147.04) 51.98,147.04 52.23,147.28 J13.21 ; C117.2 v1(12.28,60.36) ; U7.2 v1(139.67,63.73) ; R94.1 v1(22.39,160.18) ; C205.2 v1(37.5,46.65) ; C60.2 68.74,87.42 v1(68.5,87.67) ; C128.2 v1(149.52,95.29) ; U7.4 v1(142.21,63.73) ; C130.2 v1(150.86,119.8) ; C259.2 100.6,87.41 v1(101.76,87.41) ; C255.2 v1(52.4,143.04) ; v1(79.92,22.77) 79.92,21.25 79.16,20.48 D2.2 78.4,21.12 v1(78.4,22.9) ; U7.3 v1(140.94,66.9) ; C172.2 v1(18.94,152.07) ; C271.1 v1(44.61,11.21) ; v1(21.63,164.76) 21.82,164.76 Q4.S ; C213.2 v1(23.15,63.79) ; U2.V18 v2(91.8,92.37) ; C238.2 82.76,39.89 v1(81.75,39.89) ; R326.1 v1(163.11,19.6) ; C212.1 v1(21.12,57.31) ; SW2.1 v1(6.8,61.18) ; Q2.S 30.71,164.76 v1(30.52,164.76) ; C204.1 v1(21.12,54.77) ; 110.53,136.82 v1(111.26,136.82) ; C103.2 v1(88.18,25.82) ; 27.47,57.19 v1(27.47,57.95) ; v1(7.53,11.98) 10.12,11.98 SW6.1 ; R308.1 v1(160.82,19.6) ; FB19.1 v1(156.18,163.55) ; SW6.2 4.37,11.98 v1(2.45,11.98) ; v1(26.58,54.52) 26.96,54.14 C192.2 ; v1(5.57,103.03) C315.2 C314.2 ; R274.1 v1(141.77,75.98) ; C133.2 v1(136.82,128.37) ; 133.64,127.67 v1(133.64,126.94) ; Q3.S 26.26,164.76 v1(25.95,164.76) ; U17.3 v1(10.58,152.69) ; SW2.2 v1(6.8,63.1) ; U7.1 v1(138.4,66.84) ; C113.2 v1(82.21,21.25) ; C179.2 v1(103.16,16.67) ; C131.2 v1(148.58,119.8) ; BT1.2 107.2,42.07 v1(107.63,41.64) ; 106.72,24.42 v1(105.88,24.42) ; C268.2 v1(151.5,14.15) ; R95.1 v1(26.83,160.06) ; C222.2 v1(69,33.44) ; R93.1 v1(30.75,160.39) ; R360.1 v1(18.45,155.1) ; 35.72,161.07 v1(35.72,160.31) ; C86.2 v1(92.6,21.37) ; C214.2 v1(107.86,155) ; C74.2 v1(20.87,113.58) ; C8.2 v1(61.12,98.93) ; D3.1 v1(83.62,15.93) ; C272.1 v1(21.12,10.32) ; C85.2 v1(92.6,20.36)
  TOP w0.635: C241.2 v1(102.89,30.38) ; C232.2 63.17,69.9 v1(62.65,69.38) ; U29.1 v1(140.8,144.83) ; C185.2 v1(164.38,155.61) ; C320.1 v1(2.02,80.94) ; v1(4.99,93.89) 4.99,92.69 FB25.2 ; v1(93.64,42.33) 94.65,43.34 C235.2 ; C237.2 v1(89.81,44.15) ; v1(106.72,66.46) 106.19,66.46 C233.2 ; C330.2 v1(2.09,74.71) ; C359.2 v1(58.24,33.99) ; C326.1 v1(2.04,76.36) ; v1(144.06,156.31) C265.2 v1(142.95,157.49) ; C319.1 v1(12.58,50.2) ; 69.38,73.7 69.43,73.65 v1(70.55,73.65) ; C182.2 v1(124.37,150.47)
  TOP w0.762: v1(137.51,156.25) C262.2 v1(138.62,157.68)
  LY2_GND w0.483: 138.01,75.09 J7.20 137.2,74.48 ; 131.48,74.48 J8.19 130.67,75.09 ; 135.93,74.48 J7.19 135.11,75.09 ; 132.75,74.48 J8.20 133.56,75.09
  LY2_GND w0.502: J5.20 73.57,140.52 ; J5.20 73.57,138.7 ; J5.20 74.48,139.61 ; J5.20 72.66,139.61 ; 127.27,116.75 J4.7 ; J4.7 128.18,117.66 ; J4.7 128.18,115.84 ; J4.7 129.09,116.75 ; 95.16,159.02 J16.15 ; J16.15 96.07,159.93 ; J16.15 94.25,159.93 ; J16.15 95.16,160.84 ; J6.25 57.06,126.55 ; J6.25 57.97,125.64 ; J6.25 56.15,125.64 ; J6.25 57.06,124.73 ; 79.92,159.02 J16.27 ; J16.27 79.92,160.84 ; J16.27 79.01,159.93 ; J16.27 80.83,159.93 ; 103.39,6.3 J12.11 ; J12.11 100.7,8.99 ; J12.11 103.39,11.68 ; J12.11 106.08,8.99 ; J6.3 85,126.55 ; J6.3 85.91,125.64 ; J6.3 85,124.73 ; J6.3 84.09,125.64 ; J5.37 51.62,137.07 ; J5.37 50.71,137.98 ; J5.37 50.71,136.16 ; J5.37 49.8,137.07 ; 140.16,6.38 J10.MTG1 ; J10.MTG1 139.12,7.42 ; J10.MTG1 141.2,7.42 ; J10.MTG1 140.16,8.46 ; 153.62,7.42 J10.MTG2 ; J10.MTG2 154.66,8.46 ; J10.MTG2 154.66,6.38 ; J10.MTG2 155.7,7.42 ; J19.10 124.65,39.6 ; J19.10 122.82,39.6 ; J19.10 123.74,40.51 ; J19.10 123.74,38.68 ; 123.74,15.82 J19.19 ; J19.19 123.74,17.65 ; J19.19 124.65,16.74 ; J19.19 122.82,16.74 ; J42.1 165.01,134.17 ; J42.1 166.05,133.13 ; J42.1 165.01,132.09 ; J42.1 163.97,133.13 ; 71.39,128.18 J6.14 ; J6.14 72.3,129.09 ; J6.14 73.21,128.18 ; J6.14 72.3,127.27 ; 132.35,91.35 J3.28 ; J3.28 134.17,91.35 ; J3.28 133.26,92.26 ; J3.28 133.26,90.44 ; J5.11 84.64,137.07 ; J5.11 82.82,137.07 ; J5.11 83.73,136.16 ; J5.11 83.73,137.98 ; J1.3 55.79,10.9 ; J1.3 53.8,8.9 ; J1.3 55.79,6.91 ; J1.3 57.78,8.9 ; J10.MTG3 140.6,2.52 ; J10.MTG3 139.56,3.56 ; J10.MTG3 138.52,2.52 ; TP30.1 86.04,167.55 ; TP30.1 85,166.51 ; TP30.1 83.96,167.55 ; 166.51,91.35 TP28.1 ; TP28.1 167.55,90.31 ; TP28.1 167.55,92.39 ; 79.92,161.56 J16.28 ; J16.28 80.83,162.47 ; J16.28 79.01,162.47 ; J16.28 79.92,163.38 ; J10.MTG4 155.26,3.56 ; J10.MTG4 154.22,2.52 ; J10.MTG4 156.3,2.52 ; 122.82,14.2 J19.20 ; J19.20 124.65,14.2 ; J19.20 123.74,15.11 ; J19.20 123.74,13.28 ; 135.8,90.44 J3.27 ; J3.27 134.89,91.35 ; J3.27 135.8,92.26 ; J3.27 136.71,91.35 ; 50.63,57.97 49.82,58.58 50.63,59.19 ; 80.68,4.2 SW1.M2 ; SW1.M2 80.68,6.03 ; SW1.M2 79.77,5.12 ; SW1.M2 81.6,5.12 ; 25.93,1.69 J15.D2 ; J15.D2 26.78,2.54 ; J15.D2 27.63,1.69 ; J17.3 69.53,43.34 ; J17.3 67.45,43.34 ; J17.3 68.49,44.39 ; J17.3 68.49,42.3 ; TP29.1 91.86,3.75 ; TP29.1 90.82,2.7 ; TP29.1 92.9,2.7 ; TP29.1 91.86,1.66 ; 74.69,5.12 SW1.M1 ; SW1.M1 76.52,5.12 ; SW1.M1 75.6,6.03 ; SW1.M1 75.6,4.2 ; 64.68,127.27 J6.20 ; J6.20 65.59,128.18 ; J6.20 64.68,129.09 ; J6.20 63.77,128.18 ; 95.52,137.07 J5.1 ; J5.1 97.34,137.07 ; J5.1 96.43,136.16 ; J5.1 96.43,137.98 ; 86.27,138.7 J5.10 ; J5.10 87.18,139.61 ; J5.10 85.36,139.61 ; J5.10 86.27,140.52 ; 59.96,139.61 J5.30 ; J5.30 60.87,138.7 ; J5.30 60.87,140.52 ; J5.30 61.78,139.61 ; J1.2 62.58,12.15 ; J1.2 58.6,12.15 ; J1.2 60.59,10.16 ; J1.2 60.59,14.15 ; J15.1 28.71,15.15 ; J15.1 26.99,15.15 ; J15.1 27.85,16.01 ; J15.1 27.85,14.29 ; TP27.1 6.03,70.4 ; TP27.1 4.99,69.35 ; TP27.1 3.95,70.4 ; TP27.1 4.99,71.44 ; J12.10 131.08,8.99 ; J12.10 128.38,11.68 ; J12.10 125.69,8.99 ; J12.10 128.38,6.3 ; J4.8 125.64,117.66 ; J4.8 125.64,115.84 ; J4.8 124.73,116.75 ; J4.8 126.55,116.75 ; 40.35,2.87 J15.D3 ; J15.D3 41.2,3.72 ; J15.D3 39.5,3.72 ; 121.42,9.46 J12.5 ; J12.5 120.47,10.41 ; J12.5 122.38,10.41 ; J12.5 121.42,11.37 ; 123.74,51.38 J19.5 ; J19.5 124.65,52.3 ; J19.5 123.74,53.21 ; J19.5 122.82,52.3 ; 142.45,164.02 J18.4 ; J18.4 141.46,165.01 ; J18.4 142.45,166 ; J18.4 143.44,165.01
  LY2_GND w0.635: 49.82,58.58 50.96,58.58
  LY4 w0.133: 68.34,71.83 68.56,72.06 68.56,74.43 69.2,75.07 72.84,75.07 73.7,75.93 73.7,77.48 72.27,78.9 71.77,78.9 71.51,78.65 71.51,77.32 v1(71.71,77.13) 72.55,77.13 72.93,76.75 72.93,76.24 72.52,75.83 68.86,75.83 67.79,74.76 67.79,72.38 64.65,69.23 64.65,61.61 64.67,61.59 64.67,55.27 68.37,51.57 68.42,51.57 69.85,51.57 76.45,51.57 76.9,52.02 78.15,53.27 80.22,53.27 80.76,52.73 80.76,51.92 80.78,51.9 83.95,48.73 84.74,48.73 88.04,45.42 88.04,39.76 87.92,39.64 87.92,38.52 v1(88.23,38.21) 88.51,38.21 88.94,38.65 88.94,39.76 88.81,39.89 88.81,45.11 88.81,45.74 85.06,49.5 84.27,49.5 81.55,52.22 81.55,53.12 80.63,54.04 77.83,54.04 76.13,52.34 68.69,52.34 65.44,55.59 65.44,61.91 65.42,61.93 65.42,68.92 68.34,71.83
  LY5_GND w0.483: 133.56,75.09 J8.20 132.75,74.48 ; 130.67,75.09 J8.19 131.48,74.48 ; 137.2,74.48 J7.20 138.01,75.09 ; 135.93,74.48 J7.19 135.11,75.09
  LY5_GND w0.502: 39.5,3.72 J15.D3 ; J15.D3 40.35,2.87 ; J15.D3 41.2,3.72 ; J19.19 124.65,16.74 ; J19.19 123.74,15.82 ; J19.19 122.82,16.74 ; J19.19 123.74,17.65 ; J15.1 27.85,16.01 ; J15.1 27.85,14.29 ; J15.1 26.99,15.15 ; J15.1 28.71,15.15 ; 167.55,90.31 TP28.1 ; TP28.1 166.51,91.35 ; TP28.1 167.55,92.39 ; TP27.1 6.03,70.4 ; TP27.1 3.95,70.4 ; TP27.1 4.99,71.44 ; TP27.1 4.99,69.35 ; 71.39,128.18 J6.14 ; J6.14 72.3,127.27 ; J6.14 72.3,129.09 ; J6.14 73.21,128.18 ; J3.27 136.71,91.35 ; J3.27 135.8,90.44 ; J3.27 135.8,92.26 ; J3.27 134.89,91.35 ; 56.15,125.64 J6.25 ; J6.25 57.06,126.55 ; J6.25 57.97,125.64 ; J6.25 57.06,124.73 ; 133.26,90.44 J3.28 ; J3.28 133.26,92.26 ; J3.28 132.35,91.35 ; J3.28 134.17,91.35 ; 60.87,138.7 J5.30 ; J5.30 61.78,139.61 ; J5.30 59.96,139.61 ; J5.30 60.87,140.52 ; 90.82,2.7 TP29.1 ; TP29.1 91.86,3.75 ; TP29.1 91.86,1.66 ; TP29.1 92.9,2.7 ; J10.MTG4 155.26,3.56 ; J10.MTG4 156.3,2.52 ; J10.MTG4 154.22,2.52 ; J1.2 62.58,12.15 ; J1.2 60.59,10.16 ; J1.2 60.59,14.15 ; J1.2 58.6,12.15 ; 72.66,139.61 J5.20 ; J5.20 73.57,138.7 ; J5.20 74.48,139.61 ; J5.20 73.57,140.52 ; 138.52,2.52 J10.MTG3 ; J10.MTG3 140.6,2.52 ; J10.MTG3 139.56,3.56 ; 83.73,136.16 J5.11 ; J5.11 82.82,137.07 ; J5.11 83.73,137.98 ; J5.11 84.64,137.07 ; 50.71,136.16 J5.37 ; J5.37 51.62,137.07 ; J5.37 50.71,137.98 ; J5.37 49.8,137.07 ; J1.3 55.79,10.9 ; J1.3 57.78,8.9 ; J1.3 55.79,6.91 ; J1.3 53.8,8.9 ; J19.20 124.65,14.2 ; J19.20 122.82,14.2 ; J19.20 123.74,13.28 ; J19.20 123.74,15.11 ; 122.82,52.3 J19.5 ; J19.5 123.74,51.38 ; J19.5 123.74,53.21 ; J19.5 124.65,52.3 ; SW1.M2 80.68,6.03 ; SW1.M2 79.77,5.12 ; SW1.M2 80.68,4.2 ; SW1.M2 81.6,5.12 ; 153.62,7.42 J10.MTG2 ; J10.MTG2 155.7,7.42 ; J10.MTG2 154.66,8.46 ; J10.MTG2 154.66,6.38 ; J17.3 69.53,43.34 ; J17.3 68.49,42.3 ; J17.3 68.49,44.39 ; J17.3 67.45,43.34 ; J18.4 142.45,166 ; J18.4 141.46,165.01 ; J18.4 142.45,164.02 ; J18.4 143.44,165.01 ; 103.39,6.3 J12.11 ; J12.11 103.39,11.68 ; J12.11 106.08,8.99 ; J12.11 100.7,8.99 ; J16.15 96.07,159.93 ; J16.15 95.16,159.02 ; J16.15 94.25,159.93 ; J16.15 95.16,160.84 ; J6.20 65.59,128.18 ; J6.20 64.68,127.27 ; J6.20 64.68,129.09 ; J6.20 63.77,128.18 ; J4.8 125.64,117.66 ; J4.8 124.73,116.75 ; J4.8 126.55,116.75 ; J4.8 125.64,115.84 ; 95.52,137.07 J5.1 ; J5.1 96.43,137.98 ; J5.1 97.34,137.07 ; J5.1 96.43,136.16 ; 79.01,159.93 J16.27 ; J16.27 79.92,160.84 ; J16.27 80.83,159.93 ; J16.27 79.92,159.02 ; J12.10 131.08,8.99 ; J12.10 125.69,8.99 ; J12.10 128.38,11.68 ; J12.10 128.38,6.3 ; 25.93,1.69 J15.D2 ; J15.D2 26.78,2.54 ; J15.D2 27.63,1.69 ; 50.63,59.19 49.82,58.58 50.63,58.58 ; 165.01,132.09 J42.1 ; J42.1 166.05,133.13 ; J42.1 163.97,133.13 ; J42.1 165.01,134.17 ; 83.96,167.55 TP30.1 ; TP30.1 85,166.51 ; TP30.1 86.04,167.55 ; J4.7 129.09,116.75 ; J4.7 127.27,116.75 ; J4.7 128.18,117.66 ; J4.7 128.18,115.84 ; J6.3 85,126.55 ; J6.3 85,124.73 ; J6.3 84.09,125.64 ; J6.3 85.91,125.64 ; 74.69,5.12 SW1.M1 ; SW1.M1 75.6,4.2 ; SW1.M1 76.52,5.12 ; SW1.M1 75.6,6.03 ; J5.10 87.18,139.61 ; J5.10 86.27,138.7 ; J5.10 86.27,140.52 ; J5.10 85.36,139.61 ; 123.74,38.68 J19.10 ; J19.10 124.65,39.6 ; J19.10 122.82,39.6 ; J19.10 123.74,40.51 ; 79.92,161.56 J16.28 ; J16.28 79.01,162.47 ; J16.28 79.92,163.38 ; J16.28 80.83,162.47 ; 139.12,7.42 J10.MTG1 ; J10.MTG1 140.16,8.46 ; J10.MTG1 141.2,7.42 ; J10.MTG1 140.16,6.38 ; J12.5 121.42,11.37 ; J12.5 122.38,10.41 ; J12.5 121.42,9.46 ; J12.5 120.47,10.41
  BOTTOM w0.076: 95.46,64.68 C195.2
  BOTTOM w0.121: v1(86.96,67.61) 87.4,67.61 87.73,67.94 87.73,68.05 ; 43.26,108.45 42.79,107.98 42.79,99.61 40.97,97.79 v1(40.97,96.62) 40.97,95.37 40.52,94.93 40.52,85.75 40.52,85.03 v1(39.95,84.45) 39.95,83.15 37.06,80.25 37.06,69.37 41.87,64.55 v1(41.87,64.3) 41.87,59.5 41.51,59.13 41.51,58.34 42.07,57.78 42.09,57.78 42.12,57.75 42.24,57.75 v1(42.56,57.44) 42.96,57.85 v1(42.96,62.85) 42.96,64.38 37.55,69.79 37.55,80.05 40.96,83.45 v1(40.96,84.21) 40.96,84.65 41.02,84.72 41.02,84.84 41.02,94.17 41.02,94.45 41.9,95.33 v1(41.9,96.02) 41.9,98.03 43.28,99.41 43.28,107.77 47.89,112.38 49.06,112.38 v1(50.02,113.35) 50.76,114.08 50.76,115.12 v1(50.67,115.21) 50.56,115.33 50.11,115.33 49.66,114.88 49.66,114.1 48.44,112.88 47.89,112.88 45.97,112.88 44,110.91 44,109.2 43.26,108.45 ; 43.26,108.45 v1(43.01,108.7) ; 87.73,68.05 88.75,68.05 ; 87.73,68.05 84.04,71.74 84.04,73.01 v1(83.1,73.95) ; v1(86,71.32) 86,71.04 88.1,68.93 92.84,68.93 93.98,67.79 93.98,67.65 95.27,66.36 95.27,64.87 95.46,64.68 ; v1(36.88,59.59) 37.09,59.38 37.09,59.3 ; 37.09,59.3 37.36,59.3 38.28,60.23 38.28,60.43 38.73,60.87 38.73,63.18 37.28,64.63 36.79,65.11 36.46,65.11 v1(35.88,65.7) 33.46,68.11 v1(33.46,76.77) 33.46,81.34 36.59,84.47 36.59,85.99 v1(37.06,86.46) 37.45,86.85 37.45,99.43 v1(38.09,100.06) 39.64,101.61 39.64,105.69 39.33,106 v1(39.33,106.44) 39.33,106.66 39.64,106.97 39.64,111.08 39.89,111.33 39.89,111.86 40.53,112.5 40.53,112.82 40.58,112.86 v1(40.58,113.12) 41.08,113.63 41.62,113.63 41.85,113.39 41.85,112.34 40.18,110.67 40.18,100.76 v1(39.25,99.83) 37.97,98.55 37.97,86.11 37.32,85.46 v1(37.32,84.9) 37.32,84.13 34.23,81.03 v1(34.23,68.97) 34.23,68.52 39.22,63.52 39.22,60.67 38.78,60.22 38.78,60.02 38.49,59.73 38.49,59.27 v1(38.29,59.07) 37.55,58.33 37.1,58.33 36.83,58.59 36.83,59.04 37.09,59.3
  BOTTOM w0.127: v1(90.94,60.74) 90,60.74 89.98,60.77 83.83,60.77 83.25,60.18 81.24,60.18 80.37,59.31 80.37,58.87 80.14,58.64 78.65,58.64 ; 93.41,66.97 94.39,65.99 94.39,64.44 94.19,64.25 94.19,62.65 v1(93.78,62.24) ; C126.2 82.84,59.14 83.02,59.32 83.7,59.32 84.21,59.83 89.42,59.83 89.69,59.56
  BOTTOM w0.254: v1(21.85,75.52) 21.25,76.12 C324.2 ; C327.2 9.97,76.49 10.58,75.88 v1(10.63,75.88) ; C303.2 85.3,75.07 85.3,75.15 84.5,75.96 84.5,76.76 84.8,77.06 84.8,77.24 v1(85,77.44) ; U62.8 v1(104.66,54.95) 104.16,54.45 U62.4 ; v1(74.19,123.16) 74.21,123.16 74.52,122.85 C148.2 ; C316.2 18.48,84.49 v1(17.77,85.2) ; C321.2 v1(11.34,85.3)
  BOTTOM w0.305: v1(95.8,79.03) 94.96,79.03 94.72,79.28 C29.2 ; 49.82,58.58 50.08,58.58 50.71,59.22 v1(50.78,59.22) ; v1(72.81,47.66) 72.81,47.65 72.68,47.53 U27.2 ; U27.7 65.9,46.53 65.76,46.67 65.67,46.67 C215.2 v1(64.71,46.9) ; U27.1 v1(71.63,48.61)
  BOTTOM w0.381: U64.2 73.95,53.5 74.21,53.76 ; 74.21,53.76 v1(74.21,55.41) ; 74.21,53.76 74.46,53.5 U64.5 ; v2(85.8,84.2) 85.55,84.2 85.13,84.62 C35.2 ; 74.97,55.79 74.97,56.17 75.05,56.25 75.05,56.51 v1(75.18,56.64) ; C82.2 98.03,72.11 v1(97.96,72.18) ; v2(84.2,85.8) 83.98,85.58 C19.2 ; C80.2 95.99,71.86 v1(96.24,72.11) ; C83.2 85,89.8 v2(84.2,90.6) ; C174.2 89.57,56.2 89.74,56.36 89.74,56.59 v1(89.78,56.64) ; 105.07,49.11 104.86,48.91 v1(104.84,48.91) ; 105.07,49.11 105.09,49.14 106.39,49.14 106.59,48.93 C279.2 ; 105.07,49.11 C339.2 ; v1(77,53.86) 77.25,53.6 C18.2 ; C307.2 C306.2 v1(90.94,60.74) ; v1(91.38,56.64) 91.73,56.29 R572.1 ; C76.2 83.41,83.39 v2(83.4,83.4) ; v1(91.38,63.84) 91.86,63.36 C219.2 ; v2(87.4,89) 88.06,89 C94.2 ; C308.2 v1(104.98,58.58) ; C218.2 75.18,64.51 v1(75.18,63.84) ; v1(60,100.73) 60.11,100.62 R4.1 ; C260.2 24.17,85.25 v1(23.41,84.49) ; v2(87.4,84.2) 87.03,84.57 C36.2 ; C64.2 106.46,66.2 v1(106.72,66.46) ; v1(73.57,87.71) 74.5,87.71 C71.2 ; U49.2 v1(11.71,41.32) ; C278.2 v1(109.78,48.69) ; v1(63.37,59.7) 63.49,59.7 63.49,59.7 63.96,59.7 63.98,59.73 C66.2 ; C34.2 84.72,86.08 v2(84.2,86.6) ; C89.2 101.76,113.7 v1(102.15,114.08) ; v2(84.2,82.6) 84.76,82.6 C24.2 ; v1(148.88,148.98) 148.12,148.22 C184.2 ; 143.04,11.85 142.4,11.85 v1(142.15,12.1) ; C42.2 83.41,87.41 v2(83.4,87.4) ; C223.2 79.54,56.26 79.7,56.42 79.7,56.91 v1(79.18,57.44) ; v2(84.2,81.8) 84.85,81.8 C79.2 ; C203.2 v1(71.28,56.12) ; v2(87.4,81.8) 87.25,81.95 C78.2 ; C376.2 82.87,54.52 v1(82.66,54.32) ; v2(77.89,92.24) 77.89,91.73 78.02,91.6 C47.2 ; v1(89.78,63.84) 89.78,64.51 C202.2 ; v1(65.32,122.97) 64.93,122.59 C141.2 ; v1(76.34,60.74) C305.2 C304.2 ; C98.2 93.54,33.18 v1(93.51,33.22) ; R573.1 77.13,56.29 v1(76.78,56.64) ; C90.2 88.57,85.42 88.57,85.43 v2(88.2,85.8) ; C53.2 81.8,84.09 v2(81.8,83.4) 81.76,83.36 C77.2 ; C195.2 95.92,64.08 96.17,63.84 v1(96.18,63.84) 96.43,63.59 C156.2 ; v1(69,33.44) 69.25,33.69 C357.2 ; v1(76.78,63.84) 77.25,63.36 C216.2 ; v1(39.03,46.77) 38.77,47.03 C206.2 ; C27.2 81.89,88.11 v2(82.6,87.4) 82.6,86.7 C41.2 ; v1(88.18,63.84) 86.61,63.84 C225.2 C224.2 C208.2 ; 70.9,55.16 70.14,55.92 v1(70.14,56.04) ; v1(83.18,57.44) 82.84,57.77 C126.2 ; C31.2 87.4,83.3 v2(87.4,82.6) ; C188.2 94.14,57.8 v1(93.78,57.44) 94.3,56.91 94.3,56.42 94.14,56.26 C189.2 ; C87.2 24.68,106.11 v1(25.13,105.65) ; 143.04,18.33 142.4,18.33 v1(142.15,18.58) ; 74.97,86.27 74.9,86.33 v1(74.3,86.33) ; R584.2 v1(13.12,78.62) ; R541.1 v1(85,77.44) ; R304.1 v1(141.52,10.45) ; C337.2 v1(102.02,48.91) ; C205.2 v1(37.5,46.65) ; C162.2 v1(3.09,109.38) ; U48.2 v1(9.05,65.82) ; C217.2 81.32,64.08 81.56,63.84 v1(81.58,63.84) 81.58,63.84 81.83,63.59 C221.2 ; C331.1 v1(15.4,74.87) ; v1(96.18,56.64) 96.56,56.26 C181.2 ; v1(81.58,56.64) 81.95,56.26 C155.2 ; C152.2 v1(144.18,36.74) ; v1(70.27,52.87) 70.67,52.46 70.88,52.46 71.36,51.98 C20.2 ; 71.92,82.71 C30.2 ; C338.2 v1(104.05,48.93) ; C377.2 86.78,67.42 86.96,67.6 86.96,67.61 v1(86.96,67.61) ; v1(76.51,55.22) 76.68,55.22 R633.1 ; C267.2 v1(70.76,71.01) ; R22.1 v1(83.1,73.95)
  BOTTOM w0.508: C145.2 137.43,34.96 v1(137.71,34.69) ; v1(80.68,28.74) 80.81,28.74 81.32,29.25 C110.2 ; C96.2 81.23,93.09 v2(81.23,93.13) ; C1.2 63.98,99.67 v1(63.98,98.78) ; v1(15.91,110.27) 15.66,110.53 C161.2 ; C276.2 v1(98.46,48.73) ; C209.2 126.53,126.78 v1(126.15,127.16) ; v1(95.92,39.03) 95.03,38.14 95.03,37.97 C251.2 ; v1(94.33,89.89) 94.33,89.88 93.9,89.45 C50.2 ; C261.2 v1(113.59,45.01) ; C138.2 130.85,87.67 130.83,87.65 130.26,87.65 v1(129.82,87.2) ; R120.1 R121.1 v1(157.19,51.35) ; v1(87.03,25.82) 87.67,26.45 87.67,26.45 87.93,26.71 C108.2 ; R116.1 R117.1 v1(157.19,61.51) ; v1(24.8,116.62) 25.02,116.41 C163.2 ; v1(157.19,78.96) 157.12,79.03 R127.1 R126.1 ; C73.2 63.92,66.27 v1(63.73,66.46) ; C341.2 R596.1 107.38,54.18 v1(107.38,54.19) ; C236.2 81.3,26.93 v1(80.8,26.93) ; C275.2 v1(101.26,57.14) ; v1(144.94,34.07) 145.2,34.33 C142.2 ; v1(138.4,66.84) 138.91,67.35 C116.2 ; C32.2 v1(105.7,82.59) ; v1(21.88,117.13) 21.63,117.39 C164.2 ; C245.2 112.59,21.3 113.37,21.3 v1(113.58,21.5) ; v2(91.8,92.37) 91.67,92.23 C48.2 ; C358.2 67.56,49.96 68.34,50.74 69.99,50.74 70.27,50.46 C354.2 70.97,49.95 71.63,49.29 v1(71.63,48.61) ; R325.1 v1(137.58,37.38) ; v1(21.88,136.18) 21.63,136.44 C168.2 ; C104.2 v1(89.45,25.82) ; v1(82.77,95.31) 82.59,95.13 82.59,94.53 ; v1(27.47,123.61) 27.43,123.57 C165.2 ; C340.2 v1(108.42,54.52) ; C102.2 v1(97.95,39.03) ; C136.2 v1(134.53,84.62) ; C180.2 51.85,147.23 v1(51.85,147.04) ; C380.2 v1(11.85,53.38) ; C166.2 21.63,123.74 v1(21.88,123.48) ; v1(15.48,85.41) 15.28,85.2 C328.2 ; C46.2 86.65,87.45 v2(86.6,87.4) ; 95.29,113.45 v1(95.29,112.69) ; C68.2 v1(50.2,101.38) ; C150.2 v1(137.71,33.69) ; v1(90.97,42.07) 91.6,41.44 91.6,40.17 ; C101.2 97.95,36.61 98.34,36.99 v1(99.99,36.99) ; v1(21.88,129.83) 21.63,130.09 C170.2 ; C147.2 135.8,28.75 v1(136.06,28.49) ; C169.2 27.15,130.05 v1(27.42,129.78) ; R64.2 90.84,35.09 v3(90.72,34.96) ; C125.2 v1(81.34,54.74) ; R118.1 R119.1 v1(157.19,56.43) ; v1(30.26,59.09) 30.26,58.48 30.52,58.23 C196.2 ; C153.2 v1(158.53,19.09) ; 71.92,82.59 72.36,82.14 FB10.2 ; 71.92,82.59 v1(71.92,82.58) ; 71.92,82.59 71.92,82.71 ; v1(24.68,136.94) 25.31,136.94 C167.2 ; v1(27.47,96.81) R79.1 R73.1 ; C127.2 v1(149.52,98.08) ; C160.2 148.37,20.61 v1(148.5,20.74) ; C143.2 v1(144.94,32.04) ; R387.2 v1(145.64,143.36) ; R627.1 v1(12.86,85.38) ; C258.2 103.29,78.79 103.29,78.02 v1(103.16,77.89) ; C129.2 v1(149.52,117.64) ; C135.2 v1(48.17,133.39) ; R383.2 v1(138.49,145.64) ; v1(137.71,29.37) 137.83,29.25 R292.1 ; C325.2 v1(22.03,79.03) ; R114.1 R115.1 v1(157.19,66.59) ; C109.2 82.21,30.26 v1(80.68,30.26) ; R124.1 155.99,84.11 v1(157.26,84.11) ; C144.2 v1(141.64,36.74) ; C242.2 150.8,18.6 151.29,19.09 v1(151.29,19.72) ; v1(98.22,89.22) 98.21,89.22 C93.2 ; v1(140.63,29.37) 140.75,29.49 C154.2 ; v1(144.31,29.37) 144.94,30.01 C151.2 ; R122.1 R123.1 v1(157.19,89.19) ; v1(109.41,59.09) 108.38,58.06 C266.2 ; C317.2 v1(12.86,71.31) ; C91.2 v1(93.64,42.33) ; C118.2 v1(7.91,43.34) R112.1 ; v1(93.26,81.22) 93.26,82.02 ; v1(157.19,73.9) 157.14,73.95 R129.1 R128.1 ; C248.2 v1(25.07,46.54) ; C134.2 v1(71.03,122.85) ; C273.2 v1(105.56,94.51) ; v1(163.11,19.6) 162.87,19.36 C243.2 ; C277.2 v1(100.49,48.86) ; 27.47,57.19 v1(27.47,57.95) ; C322.2 v1(18.33,71.28) ; C69.2 v1(50.08,96.94) ; C146.2 v1(137.71,32.55) ; C115.2 v1(25.95,94.27)
  BOTTOM w0.635: v3(32.17,55.16) 31.91,55.16 C199.2 ; v1(84.24,99.86) 84.24,99.35 84.82,98.77 C274.2 ; C16.2 v1(65.06,78.02) ; v3(34.2,54.14) 34.84,53.5 C207.2 ; C249.2 v1(100.16,106.92) ; C52.2 68.36,81.19 68.62,80.94 v1(69.13,80.94) ; v1(87.92,95.54) 88.05,95.67 C45.2 ; v1(90.84,106.84) 90.91,106.78 90.91,105.62 C257.2 ; C157.2 136.11,14.21 v1(136.11,15.35) ; C193.2 34.84,55.16 v3(34.2,55.16) ; C56.2 73.62,80.68 v1(73.7,80.6) 73.75,80.65 74.43,80.65 C65.2 ; v3(33.18,54.14) 33.18,53.5 C201.2 ; C246.2 66.57,83.33 66.08,82.84 v1(65.06,82.84) ; v3(32.17,56.17) 31.79,56.17 R406.1 ; C200.2 31.28,53.25 v3(32.17,54.14) 32.42,53.89 C194.2 ; C23.2 71.16,72.76 v1(71.03,72.88) ; v3(33.18,56.17) 33.18,56.68 C198.2 ; C247.2 52.16,82.42 v1(52.16,81.95)
  BOTTOM w0.762: C252.2 90.42,32.13 v3(90.72,32.42) ; C250.2 88.98,35.43 v3(89.45,34.96) ; v3(88.18,34.96) 88.09,34.87 C253.2 ; v3(90.72,33.69) 90.99,33.42 C240.2 ; C280.2 v1(100.49,72.07) ; C254.2 87.96,32.64 v3(88.18,32.42)
  vias: v1(2.45,93.89) v1(2.45,91.35) v1(2.45,70.4) v1(2.45,67.86) v1(2.45,65.32) v1(2.45,59.6) v1(2.45,57.06) v1(2.45,54.52) v1(2.45,51.98) v1(2.45,49.44) v1(2.45,45.63) v1(2.45,43.09) v1(2.45,40.55) v1(2.45,27.22) v1(2.45,25.31) v1(2.45,23.41) v1(2.45,21.5) v1(2.45,19.6) v1(2.45,17.69) v1(2.45,15.79) v1(2.45,13.88) v1(2.45,10.07) v1(2.45,8.17) v1(2.45,6.26) v1(2.45,4.36) v1(2.45,2.45) v1(4.36,157.39) v1(4.36,154.85) v1(4.36,152.31) v1(4.36,149.77) v1(4.36,147.23) v1(4.94,55.26) v1(4.99,91.35) v1(4.99,67.86) v1(4.99,65.32) v1(4.99,59.6) v1(4.99,57.06) v1(4.99,51.98) v1(4.99,49.44) v1(4.99,27.22) v1(4.99,25.31) v1(4.99,23.41) v1(4.99,21.5) v1(4.99,19.6) v1(4.99,17.69) v1(4.99,13.88) v1(4.99,10.07) v1(4.99,8.17) v1(4.99,6.26) v1(4.99,4.36) v1(4.99,2.45) v1(6.26,157.39) v1(6.26,154.85) v1(6.26,149.77) v1(6.26,147.23) v1(7.53,70.4) v1(7.53,27.22) v1(7.53,25.31) v1(7.53,23.41) v1(7.53,21.5) v1(7.53,19.6) v1(7.53,17.69) v1(7.53,13.88) v1(7.53,10.07) v1(7.53,8.17) v1(7.53,6.26) v1(7.53,4.36) v1(7.53,2.45) v1(8.17,159.68) v1(8.17,157.39) v1(8.17,154.85) v1(8.17,152.31) v1(8.17,149.77) v1(8.17,147.23) v1(10.07,159.68) v1(10.07,157.39) v1(10.07,154.85) v1(10.07,152.31) v1(10.07,149.77) v1(10.07,147.23) v1(10.07,70.4) v1(10.07,27.22) v1(10.07,25.31) v1(10.07,23.41) v1(10.07,21.5) v1(10.07,19.6) v1(10.07,17.69) v1(10.07,13.88) v1(10.07,10.07) v1(10.07,8.17) v1(10.07,6.26) v1(10.07,4.36) v1(10.07,2.45) v1(11.98,167.68) v1(11.98,165.77) v1(11.98,163.87) v1(11.98,161.58) v1(11.98,159.68) v1(11.98,157.39) v1(11.98,147.23) v1(12.61,58.33) v1(12.61,56.43) v1(12.61,54.52) v1(12.61,52.62) v1(12.61,11.34) v1(12.61,5.63) v1(13.88,167.68) v1(13.88,165.77) v1(13.88,163.87) v1(13.88,161.58) v1(13.88,159.68) v1(13.88,157.39) v1(13.88,147.23) v1(13.88,48.81) v1(13.88,46.27) v1(13.88,43.73) v1(13.88,39.28) v1(13.88,35.47) v1(13.88,33.57) v1(13.88,31.66) v1(13.88,29.76) v1(13.88,27.85) v1(13.88,25.95) v1(13.88,24.04) v1(13.88,22.14) v1(13.88,20.23) v1(13.88,18.33) v1(13.88,8.8) v1(13.88,2.45) v1(15.15,58.33) v1(15.15,56.43) v1(15.15,54.52) v1(15.15,52.62) v1(15.15,11.34) v1(15.15,5.63) v1(15.79,167.68) v1(15.79,165.77) v1(15.79,163.87) v1(15.79,161.58) v1(15.79,159.68) v1(15.79,157.39) v1(15.79,149.77) v1(15.79,147.23) v1(15.79,95.16) v1(15.79,92.62) v1(16.42,39.28) v1(16.42,35.47) v1(16.42,33.57) v1(16.42,31.66) v1(16.42,29.76) v1(16.42,27.85) v1(16.42,25.95) v1(16.42,24.04) v1(16.42,22.14) v1(16.42,20.23) v1(16.42,18.33) v1(16.42,15.79) v1(16.42,8.8) v1(16.42,2.45) v1(17.69,167.68) v1(17.69,165.77) v1(17.69,163.87) v1(17.69,161.58) v1(17.69,159.68) v1(17.69,157.39) v1(17.69,152.31) v1(17.69,149.77) v1(17.69,147.23) v1(17.69,11.34) v1(17.69,5.63) v1(18.33,97.7) v1(18.33,90.08) v1(18.33,87.54) v1(18.96,39.28) v1(18.96,35.47) v1(18.96,33.57) v1(18.96,31.66) v1(18.96,29.76) v1(18.96,27.85) v1(18.96,25.95) v1(18.96,24.04) v1(18.96,22.14) v1(18.96,20.23) v1(18.96,18.33) v1(18.96,15.79) v1(18.96,8.8) v1(18.96,2.45) v1(19.6,161.58) v1(19.6,159.68) v1(19.6,157.39) v1(19.6,154.85) v1(19.6,152.31) v1(19.6,149.77) v1(19.6,147.23) v1(19.6,51.35) v1(19.6,48.81) v1(19.6,46.27) v1(20.23,11.34) v1(20.23,5.63) v1(20.87,97.7) v1(21.5,159.68) v1(21.5,157.39) v1(21.5,154.85) v1(21.5,152.31) v1(21.5,149.77) v1(21.5,147.23) v1(21.5,39.28) v1(21.5,35.47) v1(21.5,33.57) v1(21.5,31.66) v1(21.5,29.76) v1(21.5,27.85) v1(21.5,25.95) v1(21.5,24.04) v1(21.5,22.14) v1(21.5,20.23) v1(21.5,18.33) v1(21.5,15.79) v1(21.5,8.8) v1(21.5,2.45) v1(22.14,109.51) v1(22.14,108.62) v1(22.14,107.73) v1(22.14,51.35) v1(22.14,48.81) v1(22.14,46.27) v1(23.02,109.51) v1(23.02,108.62) v1(23.02,107.73) v1(23.91,109.51) v1(23.91,108.62) v1(23.91,107.73) v1(24.04,158.03) v1(24.68,27.85) v1(24.68,25.31) v1(25.95,158.03) v1(26.58,31.66) v1(27.22,27.85) v1(27.22,25.31) v1(27.22,20.23) v1(27.85,158.03) v1(27.85,151.04) v1(27.85,148.5) v1(29.76,158.03) v1(29.76,128.82) v1(29.76,126.91) v1(29.76,38.01) v1(29.76,31.66) v1(29.76,20.23) v1(30.39,151.04) v1(30.39,148.5) v1(31.66,158.03) v1(31.66,38.01) v1(32.3,128.82) v1(32.3,126.91) v1(32.3,100.24) v1(32.3,20.23) v1(33.57,158.03) v1(33.57,38.01) v1(34.84,46.9) v1(34.84,45) v1(35.47,158.03) v1(35.47,151.68) v1(35.47,149.14) v1(35.47,146.6) v1(35.47,144.06) v1(35.47,141.52) v1(35.47,138.98) v1(35.47,137.07) v1(35.47,133.26) v1(35.47,131.36) v1(36.11,39.28) v1(36.11,37.38) v1(36.11,35.47) v1(36.11,33.57) v1(36.11,31.66) v1(36.11,29.76) v1(36.11,27.85) v1(37.38,158.03) v1(37.5,168.06) v1(38.01,151.68) v1(38.01,149.14) v1(38.01,146.6) v1(38.01,144.06) v1(38.01,141.52) v1(38.01,138.98) v1(38.01,137.07) v1(38.01,133.26) v1(38.01,131.36) v1(38.65,39.28) v1(38.65,37.38) v1(38.65,35.47) v1(38.65,33.57) v1(38.65,31.66) v1(38.65,29.76) v1(38.65,27.85) v1(38.65,25.95) v1(38.65,24.04) v1(38.65,22.14) v1(39.28,158.03) v1(39.41,168.06) v1(40.55,144.06) v1(40.55,141.52) v1(40.55,138.98) v1(40.55,137.07) v1(40.55,133.26) v1(40.55,131.36) v1(41.19,163.87) v1(41.19,161.96) v1(41.19,160.06) v1(41.19,158.03) v1(41.19,39.28) v1(41.19,37.38) v1(41.19,35.47) v1(41.19,33.57) v1(41.19,31.66) v1(41.19,29.76) v1(41.19,27.85) v1(41.19,25.95) v1(41.19,24.04) v1(41.19,22.14) v1(42.36,29.91) v1(43.09,144.06) v1(43.09,141.52) v1(43.09,138.98) v1(43.09,137.07) v1(43.09,133.26) v1(43.09,131.36) v1(45.63,46.9) v1(45.63,44.36) v1(46.27,144.06) v1(46.27,141.52) v1(46.27,32.3) v1(46.27,30.39) v1(46.27,28.49) v1(46.27,26.58) v1(46.27,24.68) v1(46.27,22.77) v1(46.27,20.87) v1(46.27,18.96) v1(46.27,17.06) v1(46.27,15.15) v1(46.9,12.61) v1(46.9,10.07) v1(46.9,6.9) v1(46.9,4.36) v1(48.17,32.3) v1(48.17,29.88) v1(48.17,28.49) v1(48.17,26.58) v1(48.17,24.68) v1(48.17,22.77) v1(48.17,20.87) v1(48.17,18.96) v1(48.17,17.06) v1(48.17,15.15) v1(48.81,144.06) v1(48.81,141.52) v1(51.98,72.3) v1(51.98,69.76) v1(53.89,39.92) v1(53.89,37.38) v1(53.89,31.03) v1(58.33,78.65) v1(58.33,76.11) v1(60.87,29.76) v1(61.51,38.01) v1(63.41,29.76) v1(63.41,5.63) v1(63.41,3.72) v1(63.41,1.82) v1(64.05,38.01) v1(65.95,29.76) v1(65.95,5.63) v1(65.95,3.72) v1(65.95,1.82) v1(68.49,29.76) v1(68.49,5.63) v1(68.49,3.72) v1(68.49,1.82) v1(71.03,5.63) v1(71.03,3.72) v1(71.03,1.82) v1(71.67,28.49) v1(71.67,25.95) v1(73.57,165.01) v1(74.21,28.49) v1(74.21,25.95) v1(75.48,165.01) v1(75.48,156.12) v1(76.75,158.03) v1(76.75,15.79) v1(77.38,165.01) v1(78.02,156.12) v1(79.29,165.01) v1(79.29,158.03) v1(79.29,15.79) v1(81.19,165.01) v1(81.19,149.14) v1(83.1,165.01) v1(83.73,149.14) v1(85,165.01) v1(85,9.44) v1(86.27,5.63) v1(86.27,3.72) v1(86.91,165.01) v1(87.54,144.69) v1(87.54,9.44) v1(88.81,165.01) v1(88.81,5.63) v1(88.81,3.72) v1(90.08,144.69) v1(90.72,166.92) v1(90.72,165.01) v1(91.35,5.63) v1(92.62,166.92) v1(93.89,5.63) v1(94.53,166.92) v1(96.43,166.92) v1(97.57,54.01) v1(98.34,166.92) v1(98.34,20.87) v1(98.34,17.06) v1(98.34,15.15) v1(100.24,166.92) v1(100.88,20.87) v1(100.88,17.06) v1(100.88,15.15) v1(102.15,166.92) v1(102.78,14.52) v1(103.75,55.49) v1(103.75,54.42) v1(104.05,166.92) v1(105.32,14.52) v1(105.57,55.49) v1(105.57,54.42) v1(105.96,166.92) v1(107.86,166.92) v1(109.77,166.92) v1(110.4,102.78) v1(111.04,121.83) v1(111.04,119.93) v1(111.04,118.02) v1(111.04,116.12) v1(112.31,166.92) v1(112.94,102.78) v1(113.58,121.83) v1(113.58,119.93) v1(113.58,118.02) v1(113.58,116.12) v1(114.21,37.38) v1(114.85,166.92) v1(114.85,32.3) v1(115.48,121.83) v1(115.48,119.93) v1(115.48,118.02) v1(115.48,116.12) v1(115.48,107.86) v1(115.48,105.96) v1(115.48,104.05) v1(115.86,127.16) v1(116.12,163.11) v1(116.12,161.2) v1(116.12,159.3) v1(116.12,15.79) v1(117.39,166.92) v1(117.39,32.3) v1(118.02,121.83) v1(118.02,119.93) v1(118.02,118.02) v1(118.02,116.12) v1(118.02,107.86) v1(118.02,105.96) v1(118.02,104.05) v1(118.66,163.11) v1(118.66,161.2) v1(118.66,159.3) v1(118.66,52.62) v1(118.66,50.08) v1(118.66,15.79) v1(120.56,165.01) v1(121.2,15.79) v1(121.83,127.55) v1(122.47,157.39) v1(123.1,165.01) v1(123.1,149.14) v1(123.1,126.28) v1(124.37,127.55) v1(125.01,157.39) v1(125.64,149.14) v1(125.64,126.28) v1(126.28,65.95) v1(126.28,63.41) v1(127.55,18.96) v1(127.55,16.42) v1(127.55,13.88) v1(130.09,16.42) v1(130.09,13.88) v1(131.36,24.04) v1(131.36,22.14) v1(132.63,20.23) v1(133.9,24.04) v1(133.9,22.14) v1(133.9,3.72) v1(133.9,1.82) v1(135.17,20.23) v1(135.17,8.8) v1(135.17,6.9) v1(136.44,3.72) v1(136.44,1.82) v1(137.07,26.58) v1(137.07,24.04) v1(137.71,139.61) v1(137.71,8.8) v1(137.71,6.9) v1(138.98,35.47) v1(138.98,31.41) v1(140.25,139.61) v1(140.88,33.44) v1(142.91,35.47) v1(142.91,31.41) v1(147.23,67.86) v1(147.23,65.32) v1(147.23,60.24) v1(147.23,57.7) v1(148.12,143.55) v1(149.01,143.55) v1(150.28,143.55) v1(151.29,143.55) v1(152.56,143.29) v1(152.95,12.61) v1(153.58,48.81) v1(153.58,46.27) v1(153.58,43.73) v1(153.58,41.19) v1(153.58,32.93) v1(153.58,30.39) v1(153.58,27.85) v1(153.58,25.31) v1(154.6,145.22) v1(154.6,144.51) v1(154.6,143.78) v1(154.57,143.04) v1(154.85,11.34) v1(155.49,48.81) v1(155.49,46.27) v1(155.49,43.73) v1(155.49,41.19) v1(155.49,13.88) v1(156.12,34.84) v1(156.12,32.3) v1(156.12,29.76) v1(156.12,27.22) v1(156.25,144.18) v1(156.22,143.27) v1(157.39,48.81) v1(157.39,46.27) v1(157.39,43.73) v1(157.39,41.19) v1(157.39,13.88) v1(157.39,11.34) v1(157.39,8.8) v1(157.39,6.26) v1(158.03,32.3) v1(158.03,29.76) v1(158.03,27.22) v1(158.66,119.93) v1(158.66,118.02) v1(158.66,116.12) v1(158.66,114.21) v1(158.66,112.31) v1(158.66,110.4) v1(158.66,108.5) v1(158.66,106.59) v1(158.66,104.69) v1(158.66,102.78) v1(158.66,3.09) v1(159.93,34.84) v1(159.93,32.3) v1(159.93,29.76) v1(159.93,27.22) v1(160.57,142.79) v1(160.57,141.52) v1(160.57,138.98) v1(160.57,137.07) v1(160.57,135.17) v1(160.57,133.26) v1(160.57,131.36) v1(160.57,129.45) v1(160.57,127.55) v1(160.57,125.64) v1(161.2,3.09) v1(161.84,116.12) v1(161.84,114.21) v1(161.84,112.31) v1(161.84,110.4) v1(161.84,108.5) v1(161.84,106.59) v1(161.84,104.69) v1(161.84,102.78) v1(161.84,100.88) v1(161.84,98.97) v1(162.47,48.17) v1(162.47,46.27) v1(162.47,44.36) v1(162.47,42.46) v1(162.47,40.55) v1(162.47,38.65) v1(162.47,36.74) v1(162.47,34.84) v1(162.47,32.93) v1(162.47,31.03) v1(162.47,29.12) v1(162.47,26.58) v1(163.11,154.22) v1(163.11,152.31) v1(163.11,150.41) v1(163.11,148.5) v1(163.11,146.6) v1(163.11,144.69) v1(163.11,142.79) v1(163.11,141.52) v1(163.11,138.98) v1(163.11,137.07) v1(163.74,3.09) v1(164.38,116.12) v1(164.38,114.21) v1(164.38,112.31) v1(164.38,110.4) v1(164.38,108.5) v1(164.38,106.59) v1(164.38,104.69) v1(164.38,102.78) v1(164.38,100.88) v1(164.38,98.97) v1(165.01,48.17) v1(165.01,46.27) v1(165.01,44.36) v1(165.01,42.46) v1(165.01,40.55) v1(165.01,38.65) v1(165.01,36.74) v1(165.01,34.84) v1(165.01,32.93) v1(165.01,31.03) v1(165.01,29.12) v1(165.01,26.58) v1(165.65,154.22) v1(165.65,152.31) v1(165.65,150.41) v1(165.65,148.5) v1(165.65,146.6) v1(165.65,144.69) v1(165.65,142.79) v1(166.28,3.09) v1(166.79,140.88) v1(166.79,138.98) v1(167.55,48.17) v1(167.55,46.27) v1(167.55,44.36) v1(167.55,42.46) v1(167.55,40.55) v1(167.55,38.65) v1(167.55,36.74) v1(167.55,34.84) v1(167.55,32.93) v1(167.55,31.03) v1(167.55,29.12) v1(167.55,26.58) v1(167.55,24.04) v1(167.55,21.5) v1(168.19,154.22) v1(168.19,152.31) v1(168.19,150.41) v1(168.19,148.5) v1(168.19,146.6) v1(168.19,144.69) v1(168.19,142.79) v1(168.19,140.88) v1(168.19,138.98) v1(168.19,137.07) v1(168.19,135.17) v1(168.19,133.26) v1(168.19,131.36) v1(168.19,129.45) v1(168.19,127.55) v1(168.19,125.64) v1(168.19,123.74) v1(168.19,121.83) v1(168.19,119.93) v1(168.19,118.02) v1(168.19,116.12) v1(168.19,114.21) v1(168.19,112.31) v1(168.19,110.4) v1(168.19,108.5) v1(168.19,106.59) v1(168.19,104.69) v1(168.19,102.78) v1(168.19,100.88) v1(168.19,98.97) v3(33.18,55.16) v3(34.2,56.17) v3(89.45,33.69) v3(89.45,32.42)

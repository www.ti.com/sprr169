# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_LAYOUT_REV1_6A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AM335X_GMII1_RXDV: length 143.2
  TOP w0.102: 84.22,92.9 84.22,91.37 84.59,91 U2.J17
  TOP w0.121: R430.2 v1(41.52,57.42) ; 84.22,92.9 84.22,93.08 84.59,93.45 84.59,95.99 83.69,96.89 83.69,99.95 84.03,100.29 84.03,101.66 84.19,101.81 84.19,107.96 82.56,109.59 80.28,109.59 79.57,109.59 79.12,110.04 65.73,110.04 65.52,109.84 51.31,109.84 51.14,109.67 51.14,108.29 51.01,108.16 50.2,108.16 50.08,108.04 50.08,105.55 49.97,105.44 39.94,105.44 39.81,105.57 39.81,106.6 39.93,106.72 41.45,106.72 41.57,106.84 41.57,107.08 41.45,107.2 39.93,107.2 39.81,107.32 39.81,107.56 39.93,107.69 41.45,107.69 41.57,107.81 41.57,108.05 41.45,108.17 39.93,108.17 39.81,108.29 39.81,108.53 39.93,108.65 41.62,108.65 41.74,108.78 41.74,109.01 41.62,109.13 39.93,109.13 39.81,109.25 39.81,109.5 39.94,109.63 41.54,109.63 41.7,109.78 v1(43.41,109.78)
  BOTTOM w0.121: v1(43.41,109.78) 42.31,108.67 42.31,101.15 42.31,99.74 40.37,97.8 40.37,97.8 40.35,97.78 40.1,97.53 40.1,85.58 40.1,85.22 39.51,84.64 39.51,84.27 39.51,84.27 39.51,83.31 36.63,80.43 36.63,69.19 41.35,64.47 41.35,59.58 41.08,59.31 41.08,57.85 v1(41.52,57.42)
AM335X_GMII1_RXERR: length 20.4
  TOP w0.102: v2(84.2,89.8) U2.J15
  TOP w0.121: R317.2 v1(82.4,105.57)
  LY4 w0.102: v2(84.2,89.8) 83.82,90.18 83.82,90.76 83.87,90.81 83.87,92.9
  LY4 w0.121: v1(82.4,105.57) 82.4,104.43
  LY4 w0.133: 82.4,104.43 84.33,102.49 84.33,102.43 85.31,101.45 85.82,101.45 86.08,101.19 86.08,99.7 83.53,97.14 83.53,94.09 83.87,93.75 83.87,92.9
AM335X_GMII1_TXCLK: length 11.2
  TOP w0.102: 85.4,92.07 U2.K18
  TOP w0.121: v1(85.33,92.59) 85.33,92.14 85.4,92.07
  BOTTOM w0.121: v1(85.33,92.59) 84.87,92.59 84.75,92.72 84.75,93.08 84.87,93.2 85.23,93.2 85.36,93.33 85.36,94.04 86.27,94.96 86.27,95.29 86.36,95.38 86.36,95.39 ; 86.36,95.59 86.36,97.09 86.38,97.11 86.38,99.25 86.88,99.75 R415.2 ; 86.36,95.59 86.36,95.39 ; 86.36,95.59 86.36,95.39
AM335X_GMII1_TXD0: length 7.5
  TOP w0.102: U2.K17 85.41,91 85.76,91.35 85.76,92.8 85.66,92.9
  TOP w0.121: 85.66,92.9 85.51,93.05 85.51,93.33 85.64,93.46 85.84,93.46 85.95,93.57 85.95,93.88 85.51,94.32 85.51,94.63 85.51,94.63 85.51,96.26 86.19,96.94 R416.2
AM335X_GMII1_TXD1: length 9.9
  TOP w0.102: v2(85.8,90.6) U2.K16
  TOP w0.121: v1(87.77,97.78) 87.79,97.75 88.19,97.75 R417.2
  LY3 w0.102: v2(85.8,90.6) 85.8,92.9
  LY3 w0.133: v1(87.77,97.78) 87.77,96.02 87.59,95.85 86.75,95.85 85.8,94.89 85.8,92.9
AM335X_GMII1_TXD2: length 10
  TOP w0.102: v2(85.8,89.8) U2.K15
  TOP w0.121: R418.2 88.81,96.81 88.48,96.81 87.09,95.42 87.02,95.42 v1(86.71,95.11)
  LY3 w0.102: 86.21,92.9 86.21,90.21 v2(85.8,89.8)
  LY3 w0.121: v1(86.71,95.11) 86.71,93.4 86.21,92.9
AM335X_GMII1_TXD3: length 6.1
  TOP w0.102: 84.64,92.9 84.57,92.82 84.57,92.16 84.6,92.13 U2.J18
  TOP w0.121: R420.2 84.29,96.94 85.02,96.21 85.02,94.42 85.02,93.27 84.64,92.9
AM335X_GMII1_TXEN: length 7.6
  TOP w0.102: 85.01,92.9 84.85,92.74 84.85,92.12 84.95,92.02 84.95,90.55 U2.J16
  TOP w0.121: R421.2 85.24,96.94 85.27,96.92 85.27,94.52 85.27,93.16 85.01,92.9
AM335X_GPMC_A0: length 87.5
  TOP w0.102: v2(89.8,88.2) U2.R13
  TOP w0.121: v1(113.45,154.85) 113.58,154.85 R323.2
  LY4 w0.102: 93,87.9 92.24,87.9 92.11,87.77 90.77,87.77 90.76,87.78 90.22,87.78 89.8,88.2 v2(89.8,88.2)
  LY4 w0.133: 93,87.9 95.58,87.9 96.91,89.23 96.91,90.41 99.27,92.76 99.27,93.23 100.05,94.01 100.05,97.58 100.23,97.77 104.56,97.77 108.37,101.58 108.37,123.45 106.41,125.41 106.41,149.84 111.42,154.85 v1(113.45,154.85)
AM335X_GPMC_A1: length 25.9
  TOP w0.102: U2.V14 v2(92.73,88.6)
  LY4 w0.133: v2(92.73,88.6) 91.9,88.6 91.77,88.73 91.77,89.06 91.9,89.18 93.5,89.18 93.5,89.18 94.63,89.18 95.14,89.69 95.14,91.12 97.61,93.59 97.61,93.62 98.48,94.5 98.48,97.21 101.15,99.88 104.06,99.88 v1(104.28,99.66)
  BOTTOM w0.121: R439.2 104.05,96.89 104.58,97.42 104.58,98.44 104.71,98.56 104.72,98.56 104.84,98.69 104.84,99.83 104.72,99.96 104.41,99.96 104.28,99.83 v1(104.28,99.66)
AM335X_GPMC_A2: length 26.1
  TOP w0.102: U2.U14 91.01,88.6 91.41,89 93,89
  TOP w0.121: v1(93.57,88.62) 93.19,89 93,89
  LY4 w0.133: v1(93.57,88.62) 94.67,88.62 95.4,89.35 95.4,91.01 97.87,93.48 97.87,93.51 98.74,94.38 98.74,94.38 98.74,94.39 98.74,97.11 101.07,99.43 v1(102.91,99.43)
  BOTTOM w0.121: R457.2 102.78,96.91 103.5,97.63 103.5,101.03 103.37,101.15 103.01,101.15 102.88,101.03 102.88,99.45 v1(102.91,99.43)
AM335X_GPMC_A3: length 26.2
  TOP w0.102: v2(90.6,89) U2.T14
  LY4 w0.102: 93,89.45 91.85,89.45 91.41,89
  LY4 w0.133: v1(105.68,99.88) 105.65,99.88 105.32,100.21 101.12,100.21 98.22,97.32 98.22,94.62 97.35,93.75 97.35,93.7 94.88,91.22 94.88,89.8 94.52,89.44 94.15,89.44 94.15,89.45 93,89.45 ; v2(90.6,89) 91.41,89
  BOTTOM w0.121: R441.2 105.82,97.38 105.82,99.48 105.68,99.63 v1(105.68,99.88)
AM335X_GPMC_A4: length 75.8
  TOP w0.102: v2(89.8,89) U2.R14
  TOP w0.121: v1(102.15,154.6) 102.15,154.81 102.91,155.57 R442.2
  LY4 w0.102: v2(89.8,89) 90.22,89.42 91.54,89.42 93,90.88
  LY4 w0.133: v1(102.15,154.6) 101.7,155.04 101.07,155.04 100.72,154.7 100.72,148.42 99.27,146.98 99.27,143.65 100.06,142.86 100.06,124.65 99.3,123.89 99.3,120.81 98.72,120.23 98.72,111.87 98.31,111.47 98.31,103.01 97.11,101.81 97.11,100.44 96.83,100.16 96.83,93.91 95.99,93.07 95.19,93.07 93,90.88
AM335X_GPMC_A5: length 73
  TOP w0.102: U2.V15 93,89.4
  TOP w0.121: v1(101.38,154.6) 101.38,154.68 100.37,155.7 R509.2 ; 93,89.4 94.65,89.4 94.78,89.53 94.78,90.41 94.58,90.61 v1(94.43,90.61)
  LY4 w0.133: v1(94.43,90.61) 94.43,91.15 97.09,93.8 97.09,98.49 97.37,98.77 97.37,101.71 98.57,102.91 98.57,111.22 99.27,111.92 99.27,120 100.98,121.7 100.98,125.59 101.71,126.33 101.71,146.09 101.38,146.42 v1(101.38,154.6)
AM335X_GPMC_A6: length 73.5
  TOP w0.102: 92.11,89.97 92.01,89.87 91.46,89.87 91,89.41 U2.U15
  TOP w0.121: R446.2 98.46,154.72 v1(98.46,154.6) ; 92.11,89.97 92.15,89.97 93.26,91.08 94.2,91.08 95.6,92.49 95.6,93.01 95.8,93.21 v1(95.8,93.52)
  LY4 w0.133: v1(95.8,93.52) 95.9,93.62 95.9,94.27 96.56,94.92 96.56,95.74 96.18,96.13 96.18,98.97 95.67,99.48 95.67,109.45 96.56,110.34 96.56,115.98 95.6,116.94 95.6,120.13 94.19,121.54 94.19,125.26 95.1,126.16 95.1,132.41 95.09,132.41 95.09,132.79 95.1,132.79 95.1,142.28 95.6,142.79 95.6,151.74 v1(98.46,154.6)
AM335X_GPMC_A7: length 73.2
  TOP w0.102: v2(90.6,89.8) U2.T15
  TOP w0.121: v1(95.41,155.74) R510.2
  LY3 w0.121: v1(95.41,155.74) 94.08,154.41 v1(91.41,154.41)
  LY4 w0.133: v2(90.6,89.8) 91.25,89.8 91.88,90.44 91.88,91.65 92.42,92.19 92.42,98.94 92.46,98.98 92.46,106.22 92.46,106.22 92.46,109.15 92.12,109.49 92.12,121.78 91.69,122.21 91.69,135.06 92.62,135.99 92.62,142.79 91.41,143.99 v1(91.41,154.41)
AM335X_GPMC_A8: length 71.5
  TOP w0.102: 93,91.17 92.04,90.21 91.81,90.21 U2.V16
  TOP w0.121: 93,91.17 93.16,91.33 94.09,91.33 95.36,92.59 95.36,93.7 95.95,94.29 95.95,94.94 v1(96.05,95.05) ; R511.2 v1(91.1,155.74)
  LY4 w0.133: v1(91.1,155.74) 91.1,155.35 91.59,154.85 91.6,154.85 91.86,154.59 91.86,154.22 91.85,154.21 91.85,144.44 92.93,143.36 92.93,135.93 93.32,135.54 93.32,122.71 92.75,122.13 92.75,113.38 95.29,110.84 95.29,98.72 95.61,98.39 95.61,96.04 96.05,95.6 v1(96.05,95.05)
AM335X_GPMC_A9: length 81.5
  TOP w0.102: U2.U16 91.03,90.2 91.41,90.59 92.07,90.59 93.06,91.58
  TOP w0.121: v1(95.51,94.47) 95.51,94.46 95.11,94.07 95.11,92.7 93.99,91.58 93.06,91.58
  LY3 w0.133: v1(92.2,132.64) 90.99,132.64 90.4,132.05 75.54,132.05 74.9,131.42 59.03,131.42 v1(58.84,131.23)
  LY4 w0.133: v1(92.2,132.64) 91.95,132.39 91.95,122.63 92.38,122.2 92.38,113.24 94.21,111.42 94.21,108.69 94.91,107.99 94.91,98.61 95.35,98.17 95.35,95.93 95.51,95.78 v1(95.51,94.47)
  BOTTOM w0.121: R512.2 v1(58.84,131.23)
AM335X_GPMC_A10: length 115.4
  TOP w0.102: v2(90.6,90.6) U2.T16
  TOP w0.121: R230.2 v1(139.48,153.07)
  LY3 w0.133: v1(139.48,153.07) 138.59,153.07 136.63,151.1 98.34,151.1 97.45,151.99 v1(90.78,151.99)
  LY4 w0.133: v1(90.78,151.99) 91.1,151.68 91.1,143.04 92.36,141.78 92.36,136.73 91.75,136.11 91.74,136.11 90.79,135.17 90.79,122.55 91.86,121.49 91.86,109.64 91.54,109.32 91.54,107.36 91.93,106.97 91.94,106.97 92.2,106.7 92.2,106.33 92.2,106.33 92.2,103.54 91.86,103.2 91.86,92.99 91.17,92.3 91.17,91.17 v2(90.6,90.6)
AM335X_GPMC_A11: length 96.5
  TOP w0.102: v2(92.37,91.43) 91.94,91 U2.V17
  TOP w0.121: v1(97.7,133.51) 92.32,133.51 92.27,133.57 88.67,133.57 88.37,133.26 84.56,133.26 81.44,130.15 65.95,130.15 65.89,130.21 60.55,130.21 60.36,130.02 56.23,130.02 55.16,131.1 55.16,132.12 v1(54.52,132.75)
  BOTTOM w0.102: v2(92.37,91.43) 92.37,92.9
  BOTTOM w0.121: 92.37,92.9 92.37,94.14 93,94.78 95.16,94.78 96.37,95.99 96.37,99.94 97.01,100.58 97.01,101.84 98.15,102.97 98.15,115.9 98.83,116.59 98.83,123.62 99.08,123.87 99.08,124.24 98.83,124.49 98.83,124.67 98.43,125.07 97.64,125.07 97.39,125.33 97.39,125.7 97.83,126.14 97.83,132.69 97.7,132.82 v1(97.7,133.51) ; R233.2 v1(54.52,132.75)
AM335X_GPMC_AD0: length 70.2
  TOP w0.102: 93,83.41 91.41,83.41 91,83 U2.U7
  TOP w0.121: R140.2 v1(139.61,106.26) ; v1(96.48,85.14) 96.28,84.93 96.23,84.93 95.82,84.53 95.82,83.35 95.48,83 94.96,83 94.55,83.41 93,83.41
  BOTTOM w0.121: v1(96.48,85.14) 96.48,85.37 96.75,85.64 96.75,85.7 97.08,86.03 97.65,86.03 97.78,86.16 98.94,86.16 99.14,85.96 111.4,85.96 114.86,89.41 128.81,89.41 129.57,90.18 131.56,90.18 132.16,89.58 137.09,89.58 138.05,90.54 138.05,92.04 137.88,92.21 137.88,98.48 137.26,99.1 137.26,100.57 139.34,102.66 139.34,103.84 140.05,104.55 140.05,105.82 v1(139.61,106.26)
AM335X_GPMC_AD1: length 71
  TOP w0.102: 92.16,83 U2.V7
  TOP w0.121: 92.16,83 94.54,83 94.78,82.76 95.58,82.76 96.07,83.24 96.07,84.43 96.33,84.69 96.79,84.69 v1(97.25,85.14) ; R169.1 v1(139.61,107.66)
  BOTTOM w0.121: v1(97.25,85.14) 97.25,85.44 97.59,85.78 97.75,85.78 97.88,85.91 98.84,85.91 99.04,85.71 111.5,85.71 114.96,89.17 121.17,89.17 128.91,89.17 129.67,89.93 131.4,89.93 131.99,89.34 137.19,89.34 138.3,90.44 138.3,92.29 138.13,92.46 138.13,98.66 137.56,99.22 137.56,100.53 139.59,102.55 139.59,103.74 140.3,104.45 140.3,106.97 v1(139.61,107.66)
AM335X_GPMC_AD2: length 77.5
  TOP w0.102: v2(89.8,83.4) U2.R8
  TOP w0.121: v1(139.61,110.27) 140.12,109.77 R142.2 ; v1(140.01,90.46) 138.74,90.46 138.11,89.84 137.68,89.4 132.56,89.4 131.6,90.36 129.84,90.36 128.96,89.47 117.17,89.47 116.76,89.06 106.91,89.06 105.83,87.98 v1(105.83,87.67)
  LY3 w0.133: v1(105.83,87.67) 105.57,87.67 101.89,83.98 97.57,83.98 96.57,82.98 93.6,82.98 92.78,83.8 90.2,83.8 v2(89.8,83.4)
  BOTTOM w0.121: v1(140.01,90.46) 139.78,90.69 139.78,94.37 140.3,94.88 140.3,97.88 139.51,98.67 139.51,101.77 140.55,102.81 140.55,108.83 140.12,109.26 140.12,109.77 v1(139.61,110.27)
AM335X_GPMC_AD3: length 78.5
  TOP w0.102: v2(90.6,83.4) U2.T8
  TOP w0.121: v1(140.63,90.69) 140.42,90.9 138.83,90.9 137.57,89.65 132.66,89.65 131.7,90.61 129.74,90.61 128.85,89.72 116.95,89.72 116.54,89.32 106.53,89.32 v1(105.89,88.68) ; R143.2 140.6,110.43 v1(140.6,110.27)
  LY3 w0.133: v2(90.6,83.4) 90.77,83.57 92.44,83.57 93.29,82.72 97.57,82.72 97.95,83.1 97.95,83.1 98.58,83.72 102.62,83.72 106.46,87.57 106.46,87.92 106.27,88.11 106.27,88.31 v1(105.89,88.68)
  BOTTOM w0.121: v1(140.63,90.69) 140.52,90.69 140.03,91.18 140.03,94.26 140.55,94.78 140.55,97.99 139.76,98.78 139.76,101.67 140.79,102.71 140.79,109.14 140.6,109.33 v1(140.6,110.27)
AM335X_GPMC_AD4: length 79.6
  TOP w0.102: U2.U8 91,83.82 91.41,84.24 92.12,84.24
  TOP w0.121: v1(104.48,87.21) 104.48,88.45 105.64,89.61 115.74,89.61 117.61,91.48 123.23,91.48 124.74,89.97 128.75,89.97 129.64,90.85 131.8,90.85 132.76,89.9 137.47,89.9 139.05,91.48 v1(140.5,91.48) ; v1(95.24,83.48) 94.94,83.78 94.94,84.09 94.68,84.35 92.23,84.35 92.12,84.24 ; R144.2 v1(139.61,111.59)
  LY3 w0.133: v1(104.48,87.21) 101.52,84.24 97.47,84.24 97.46,84.24 97.4,84.24 96.4,83.24 95.48,83.24 v1(95.24,83.48)
  BOTTOM w0.121: v1(140.5,91.48) 140.28,91.7 140.28,94.16 140.79,94.68 140.79,98.09 140.11,98.77 140.11,101.61 141.04,102.54 141.04,111.16 140.61,111.59 v1(139.61,111.59)
AM335X_GPMC_AD5: length 79.2
  TOP w0.102: 93,83.8 U2.V8
  TOP w0.121: R161.1 v1(139.61,112.99) ; v1(94.49,83.91) 94.38,83.8 93,83.8 ; v1(140.75,92.23) 140.75,92.24 140.5,91.99 139.21,91.99 137.37,90.14 132.86,90.14 131.9,91.1 129.54,91.1 128.65,90.22 124.87,90.22 123.34,91.74 117.52,91.74 115.64,89.86 104.64,89.86 103.72,88.94 v1(103.72,87.18)
  LY3 w0.133: v1(103.72,87.18) 103.72,86.93 101.32,84.53 98.63,84.53 98.62,84.52 98.25,84.52 98.08,84.69 95.03,84.69 94.63,84.29 94.63,84.04 v1(94.49,83.91)
  BOTTOM w0.121: v1(139.61,112.99) 141.29,111.31 141.29,102.44 140.36,101.51 140.36,98.87 141.04,98.19 141.04,94.57 140.53,94.06 140.53,92.46 v1(140.75,92.23)
AM335X_GPMC_AD6: length 73.9
  TOP w0.102: v2(89.8,84.2) U2.R9
  TOP w0.121: R159.1 v1(139.61,114.39) ; v1(138.34,103.16) 132.61,103.16 129.8,100.36 114.02,100.36 112.51,98.84 103.45,98.84 102.12,97.51 100.69,97.51 v1(100.49,97.32)
  LY4 w0.133: v1(100.49,97.32) 100.49,94.09 99.74,93.34 99.74,91.32 98.75,90.32 98.45,90.32 97.57,89.45 97.57,89.15 95.21,86.79 93.83,86.79 93.47,86.43 91.36,86.43 90.94,86.01 90.18,86.01 89.59,85.42 89.59,85.4 89.38,85.19 89.38,84.72 89.63,84.46 89.63,84.37 v2(89.8,84.2)
  BOTTOM w0.121: v1(139.61,114.39) 138.92,113.7 138.92,105.07 138.6,104.75 138.6,103.42 v1(138.34,103.16)
AM335X_GPMC_AD7: length 84.2
  TOP w0.102: v2(90.6,84.2) U2.T9
  TOP w0.121: v1(141.13,94.04) 140.52,93.43 138.19,93.43 137.24,92.48 132.39,92.48 131.89,91.98 129.64,91.98 128.86,92.76 117.14,92.76 115.23,90.85 108.65,90.85 108.64,90.86 106.32,90.86 106.31,90.85 103.34,90.85 103.27,90.79 99.35,90.79 99.05,91.09 v1(98.41,91.09) ; R147.2 v1(140.63,115.73)
  LY4 w0.102: 90.76,87 90.77,87.01 93,87.01
  LY4 w0.133: v2(90.6,84.2) 90.2,83.8 89.66,83.8 89.66,83.8 89.64,83.8 89.4,84.04 89.4,84.06 89.4,84.06 89.4,84.36 89.14,84.62 89.14,85.38 89.4,85.64 89.4,85.65 89.95,86.2 89.96,86.2 90.2,86.44 90.2,86.45 90.2,86.46 90.2,86.76 90.44,87 90.76,87 ; 93,87.01 93.13,87.01 93.18,87.05 95.11,87.05 95.93,87.87 97.19,89.14 97.19,89.45 97.56,89.81 97.56,90.42 98.23,91.09 v1(98.41,91.09)
  BOTTOM w0.121: v1(141.13,94.04) 141.13,94.27 141.29,94.43 141.29,98.29 140.61,98.98 140.61,101.4 141.54,102.33 141.54,111.8 140.63,112.71 v1(140.63,115.73)
AM335X_GPMC_AD8: length 30.8
  TOP w0.102: U2.U10 91,85.41 91.35,85.76 92.04,85.76
  TOP w0.121: v1(103.03,91.35) 103.28,91.1 104.94,91.1 R261.2 ; v1(94.02,86.35) 93.8,86.13 92.4,86.13 92.04,85.76
  LY3 w0.133: v1(103.03,91.35) 103.03,90.18 102.91,90.05 101.76,90.05 101.64,89.93 101.64,88.63 101.51,88.51 101.28,88.51 101.15,88.38 101.15,87.31 101.03,87.18 97.14,87.18 97.01,87.06 97.01,86.6 97.14,86.47 101.48,86.47 101.61,86.35 101.61,85.98 101.48,85.85 98.4,85.85 98.39,85.85 94.52,85.85 v1(94.02,86.35)
AM335X_GPMC_AD9: length 22.7
  TOP w0.102: U2.T10 v2(90.6,85)
  TOP w0.121: R149.2 103.42,92.62 v1(102.4,91.6)
  LY3 w0.133: v1(102.4,91.6) 102.72,91.92 103.35,91.92 103.48,91.79 103.48,87.78 103.35,87.66 103.26,87.66 103.14,87.53 103.14,86.71 102.01,85.59 99.66,85.59 99.66,85.59 94.86,85.59 94.27,85 93.69,85 93.46,85.23 90.73,85.23 90.6,85.1 v2(90.6,85)
AM335X_GPMC_AD10: length 39.5
  TOP w0.102: U2.T11 v2(90.6,86.6)
  TOP w0.121: v1(107.86,86.98) 107.91,86.98 108.36,87.43 108.86,87.43 R242.2
  LY4 w0.133: v1(102.6,87.18) 102.17,86.75 101.18,86.75 101.05,86.63 101.05,86.07 101.18,85.94 114.46,85.94 114.59,86.07 114.59,86.42 114.46,86.54 107.99,86.54 107.86,86.67 v1(107.86,86.98)
  BOTTOM w0.102: v2(90.6,86.6) 90.6,86.51 91.1,86.02 92.9,86.02
  BOTTOM w0.121: v1(102.6,87.18) 101.87,86.45 99.6,86.45 99.4,86.65 96.52,86.65 95.99,87.19 95.49,87.19 95.09,86.79 93.83,86.79 93.06,86.02 92.9,86.02
AM335X_GPMC_AD11: length 48.4
  TOP w0.102: U2.U12 91.47,87.47 91.94,87.47 91.94,87.48 v2(92.75,87.48)
  TOP w0.121: R243.2 109.77,84.62 108.83,84.62 108.57,84.87 108.57,86.89 v1(108.67,86.99)
  BOTTOM w0.102: v2(92.75,87.48) 91.26,87.48 91.19,87.4 91.19,86.86 91.48,86.57 92.55,86.57
  BOTTOM w0.121: v1(108.67,86.99) 108.67,88.58 108.8,88.71 109.54,88.71 109.66,88.84 109.66,90.05 109.54,90.18 107.5,90.18 107.38,90.05 107.38,86.85 107.25,86.73 105.27,86.73 105.14,86.85 105.14,88.46 105.02,88.58 104.63,88.58 104.51,88.46 104.51,87.78 104.38,87.65 103.97,87.65 103.85,87.78 103.85,88.66 103.72,88.78 103.39,88.78 103.26,88.66 103.26,87.78 103.14,87.65 102.78,87.65 102.65,87.78 102.65,88.36 102.53,88.49 98.36,88.49 98.23,88.36 98.23,87.9 98.36,87.77 100.79,87.77 100.91,87.64 100.91,87.31 100.79,87.18 97.19,87.18 97.03,87.34 97.03,88.37 96.91,88.5 95.99,88.5 95.87,88.37 95.87,87.85 95.74,87.73 95.31,87.73 94.86,87.28 93.63,87.28 92.92,86.57 92.55,86.57
AM335X_GPMC_AD12: length 45
  TOP w0.102: U2.T12 v2(90.6,87.4)
  TOP w0.121: v1(111.39,87.13) 111.75,86.78 R152.2
  LY4 w0.133: v1(111.39,87.13) 111.07,87.45 111.07,90.4 110.81,90.66 109.54,90.66 109.41,90.54 109.41,90.08 109.54,89.95 109.95,89.95 110.08,89.83 110.08,87.77 109.95,87.64 107.38,87.64 107.25,87.77 107.25,88.38 107.38,88.51 108.22,88.51 108.34,88.63 108.34,89.14 108.22,89.27 101.81,89.27 101.69,89.14 101.69,88.76 101.81,88.63 105.14,88.63 105.27,88.51 105.27,87.98 105.14,87.86 101.81,87.86 101.69,87.98 v1(101.69,88.05)
  BOTTOM w0.102: 92.67,86.32 91.42,86.32 90.6,87.14 v2(90.6,87.4)
  BOTTOM w0.121: 92.67,86.32 92.69,86.3 93,86.3 93.73,87.04 94.99,87.04 95.43,87.48 95.99,87.48 96.12,87.61 96.12,88.1 96.24,88.23 96.66,88.23 96.79,88.1 96.79,87.03 96.91,86.9 101.12,86.9 101.28,87.06 101.28,87.64 v1(101.69,88.05)
AM335X_GPMC_AD13: length 21.8
  TOP w0.102: U2.R12 v2(89.8,87.4)
  TOP w0.121: R247.2 v1(96.37,89.88)
  BOTTOM w0.102: 93.26,87.87 91.73,87.87 91.65,87.79 90.21,87.79 89.81,87.4 v2(89.8,87.4)
  BOTTOM w0.121: 93.26,87.87 93.91,87.87 94.01,87.97 95.41,87.97 95.54,88.1 95.54,89.75 95.67,89.88 95.72,89.88 95.85,90 95.85,91.22 95.72,91.35 95.34,91.35 95.24,91.45 95.24,92.47 95.52,92.75 96.48,92.75 96.94,93.2 97.22,93.2 97.55,93.53 97.55,94.19 97.73,94.36 97.98,94.36 98.11,94.24 98.11,93.38 97.98,93.26 97.9,93.26 97.78,93.13 97.78,92.52 97.64,92.39 97.16,92.39 96.37,91.59 v1(96.37,89.88)
AM335X_GPMC_AD14: length 29.1
  TOP w0.102: U2.V13 91.8,88.02 91.93,88.15 93,88.15
  TOP w0.121: v1(98.36,92.54) 98.97,92.54 99.1,92.67 99.1,93.64 99.22,93.77 99.63,93.77 99.76,93.64 99.76,92.06 99.63,91.93 96.3,91.93 96.05,91.68 95.79,91.68 95.66,91.55 95.66,89.9 95.53,89.78 95.17,89.78 95.04,89.65 95.04,89.18 94.92,89.06 94.65,89.06 94.53,88.93 94.53,88.48 94.65,88.35 94.81,88.35 94.93,88.23 94.93,87.79 94.81,87.66 93.26,87.66 93.13,87.79 93.13,88.02 93,88.15 ; v1(101.07,94.94) 100.39,94.27 R248.2
  BOTTOM w0.121: v1(98.36,92.54) 98.36,91.62 98.23,91.5 97.27,91.5 97.14,91.37 97.14,90.72 97.27,90.59 98.97,90.59 99.1,90.72 99.1,93.84 99.22,93.97 100.94,93.97 101.07,94.09 v1(101.07,94.94)
AM335X_GPMC_AD15: length 11.2
  TOP w0.102: U2.U13 91.03,87.8 91.4,88.18 91.43,88.18 v2(91.4,88.2)
  TOP w0.121: R155.2 96.46,93.97 v1(96.35,94.07)
  BOTTOM w0.102: v2(91.4,88.2) 93,88.2 93.02,88.18
  BOTTOM w0.121: v1(96.35,94.07) 96.35,93.38 96,93.03 95.31,93.03 94.93,92.65 94.93,89.29 93.94,88.3 93.94,88.28 93.84,88.18 93.02,88.18
AM335X_GPMC_ADVN_ALE: length 62.6
  TOP w0.102: v2(89.8,82.6) U2.R7
  TOP w0.121: R137.2 140.12,98.28 v1(139.51,97.67)
  BOTTOM w0.102: v2(89.8,82.6) 89.8,82.55 90.17,82.18 91.27,82.18
  BOTTOM w0.121: v1(139.51,97.67) 138.79,96.96 138.79,90.24 137.4,88.84 131.68,88.84 131.09,89.43 129.88,89.43 129.12,88.67 115.58,88.67 115.17,88.67 111.71,85.21 98.83,85.21 98.63,85.41 98.24,85.41 98.02,85.19 98.02,85.18 98,85.15 98,84.75 96.01,82.77 91.86,82.77 91.27,82.18
AM335X_GPMC_BE0N_CLE: length 59.3
  TOP w0.102: v2(90.6,81.8) U2.T6
  TOP w0.121: R136.2 140.12,95.72 v1(139.61,95.21)
  BOTTOM w0.102: 91.92,82.52 91.2,81.8 v2(90.6,81.8)
  BOTTOM w0.121: v1(139.61,95.21) 139.29,94.89 139.29,90.03 137.6,88.35 131.36,88.35 130.77,88.94 130.09,88.94 129.32,88.18 115.64,88.18 112.19,84.72 98.81,84.72 97.79,83.7 97.29,83.7 96.11,82.52 91.92,82.52
AM335X_GPMC_BE1N: length 150.1
  TOP w0.102: 90.94,92.9 90.94,91.86 U2.U18
  TOP w0.121: R491.2 v1(23.91,114.31) ; 90.94,92.9 90.94,93.69 92.67,95.42 93.95,95.42 94.27,95.73 96.75,95.73 97.42,96.41 97.42,96.89 98.14,97.6 99.8,97.6 99.99,97.79 99.99,100.14 101.59,101.74 v1(105.88,101.74)
  LY3 w0.133: v1(23.91,114.31) 24.68,113.55 35.01,113.55 39.03,117.57 43.82,117.57 43.95,117.7 43.95,117.99 43.82,118.12 40.07,118.12 39.94,118.25 39.94,118.53 40.07,118.66 51.8,118.66 53.29,120.15 63.16,120.15 63.28,120.03 63.28,119.72 63.16,119.59 56.76,119.59 56.63,119.47 56.63,119.17 56.76,119.05 73.78,119.05 75.94,121.2 81.61,121.2 82.37,120.44 103.73,120.44 104.75,119.42 106.31,119.42 v1(106.36,119.47)
  BOTTOM w0.121: v1(106.36,119.47) 106.36,119.06 106.21,118.91 106.21,113.83 105.88,113.5 v1(105.88,101.74)
AM335X_GPMC_CLK: length 150.8
  TOP w0.102: U2.V12 91.89,87.09
  TOP w0.121: v1(107.35,95.03) 106.46,95.03 106.21,95.29 104.99,95.29 101.36,91.66 97.13,91.66 96.86,91.4 96.86,91.4 96.56,91.1 96.56,90.69 95.91,90.04 95.91,89.48 95.54,89.12 95.54,88.05 94.91,87.42 93.24,87.42 92.91,87.09 91.89,87.09 ; v1(19.29,114.36) 18.82,113.9 18.82,109.37 R492.1
  LY3 w0.133: v1(19.29,114.36) 20.33,115.4 24.39,115.4 24.54,115.25 25.28,115.25 25.7,114.84 34.67,114.84 39.58,119.75 51.09,119.75 52.54,121.2 66.79,121.2 67.88,122.29 74.23,122.29 74.61,122.67 77.56,122.67 78.4,123.51 79.46,123.51 79.59,123.38 79.59,122.67 79.71,122.54 80.38,122.54 80.5,122.67 80.5,123.2 80.63,123.33 81.52,123.33 81.65,123.2 81.65,122.67 81.77,122.54 82.51,122.54 82.64,122.67 82.64,123.1 82.76,123.23 83.37,123.23 83.5,123.1 83.5,122.69 83.5,122.69 83.5,121.79 83.63,121.66 107.23,121.66 v1(107.66,122.08)
  BOTTOM w0.121: v1(107.66,122.08) 108.24,121.5 108.24,103.97 108.42,103.8 108.42,100.54 108.06,100.19 108.06,96.96 107.35,96.25 v1(107.35,95.03)
AM335X_GPMC_CS0N: length 58.6
  TOP w0.102: U2.V6 92.09,82.2 92.35,82.47 93,82.47
  TOP w0.121: v1(139.56,96.43) 140.12,96.99 R135.2 ; v1(98.44,84.97) 98.44,84.91 95.79,82.26 94.52,82.26 94.32,82.47 93,82.47
  BOTTOM w0.121: v1(98.44,84.97) 98.72,84.97 98.73,84.97 111.81,84.97 115.27,88.42 115.47,88.42 129.22,88.42 129.98,89.18 130.98,89.18 131.57,88.59 137.5,88.59 139.04,90.13 139.04,95.91 v1(139.56,96.43)
AM335X_GPMC_CS1N: length 120.3
  TOP w0.102: U2.U9 91.01,84.6 91.41,85 92.19,85
  TOP w0.121: v1(95.25,85.14) 94.96,84.85 92.34,84.85 92.19,85 ; R638.2 v1(159.3,140.75) ; R175.1 99.99,89.6 v1(100.42,90.03)
  LY3 w0.133: v1(100.42,90.03) 101.95,91.56 101.95,91.79 102.47,92.31 105.12,92.31 107.1,90.33 115.61,90.33 120.12,94.85 136.37,94.85 136.69,94.53 139.61,94.53 140.5,95.41 143.29,95.41 143.96,94.74 143.96,93.73 144.76,92.93 146.65,92.93 148.82,95.1 148.82,114.78 151.55,117.51 151.55,133.01 v1(159.3,140.75)
  LY4 w0.133: v1(95.25,85.14) 95.25,85.28 97.93,87.96 99.18,87.96 99.66,88.43 99.66,89.27 v1(100.42,90.03)
AM335X_GPMC_CS2N: length 16.9
  TOP w0.121: v1(100.49,93.41) 100.49,92.87 R173.1 ; v1(95.38,84.2) 95.38,84.21 95.35,84.24 95.35,84.34 95.09,84.6 U2.V9
  LY4 w0.133: v1(100.49,93.41) 100.49,91.91 100.87,91.54 100.87,89.17 99.16,87.46 97.94,87.46 95.92,85.44 95.92,84.81 95.47,84.36 95.46,84.36 95.35,84.25 95.35,84.23 v1(95.38,84.2)
AM335X_GPMC_CS3N: length 150.1
  TOP w0.102: v2(90.6,88.2) U2.T13
  TOP w0.121: R460.2 v1(22.77,114.31)
  LY3 w0.133: v1(106.72,118.73) 105.07,118.73 103.62,120.18 82.27,120.18 81.5,120.94 76.05,120.94 73.89,118.79 56.61,118.79 55.71,119.69 53.34,119.69 52.06,118.4 44.33,118.4 44.21,118.27 44.21,117.97 44.33,117.84 52.06,117.84 52.18,117.72 52.18,117.44 52.06,117.31 39.28,117.31 35.16,113.19 23.89,113.19 v1(22.77,114.31)
  LY4 w0.102: v2(90.6,88.2) 90.98,88.58 91.56,88.58 91.94,88.2 93,88.2
  LY4 w0.133: v1(106.72,118.73) 106.72,100.29 105.73,99.31 104.45,98.03 100.03,98.03 99.79,97.78 99.79,94.12 98.73,93.07 98.13,93.07 97.91,92.85 97.91,92.06 95.92,90.06 95.92,89.5 95.54,89.12 95.54,88.5 95.21,88.17 93.03,88.17 93,88.2
AM335X_GPMC_OEN_REN: length 67.8
  TOP w0.102: v2(90.6,82.6) U2.T7
  TOP w0.121: v1(140.11,103.47) 140.11,104.16 R189.2
  BOTTOM w0.102: 93,83.02 91.02,83.02 v2(90.6,82.6)
  BOTTOM w0.121: 93,83.02 95.91,83.02 97.75,84.86 97.75,85.26 97.76,85.27 97.76,85.38 98.04,85.66 98.73,85.66 98.93,85.46 111.61,85.46 115.06,88.92 115.68,88.92 129.02,88.92 129.78,89.68 131.25,89.68 131.84,89.09 137.3,89.09 138.55,90.34 138.55,98.61 137.81,99.35 137.81,100.42 140.11,102.72 v1(140.11,103.47)
AM335X_GPMC_WAIT: length 61.7
  TOP w0.102: 90.59,92.9 90.59,91.35 90.24,91 U2.T17
  TOP w0.121: R133.2 139.23,103.67 138.89,103.67 138.71,103.85 137.6,103.85 136.24,105.21 132.49,105.21 131.74,104.46 131.74,103.8 130.47,102.53 119.04,102.53 118.02,101.51 113.37,101.51 113.19,101.33 108.01,101.33 107.16,102.19 96.5,102.19 95.26,100.94 95.26,98.14 94.2,97.08 94.2,96.02 93.85,95.67 92.37,95.67 90.59,93.89 90.59,92.9
AM335X_GPMC_WEN: length 70.1
  TOP w0.102: U2.U6 91.03,82.2 91.41,82.59 92.09,82.59 92.21,82.71 93,82.71
  TOP w0.121: 93,82.71 94.42,82.71 94.55,82.59 94.55,82.59 94.63,82.51 95.68,82.51 96.49,83.32 96.49,84.23 v1(96.51,84.24) ; R191.2 v1(139.61,104.99)
  BOTTOM w0.121: v1(96.51,84.24) 96.51,84.25 96.49,84.25 95.8,84.94 95.8,85.77 95.99,85.97 96,85.97 96.31,86.28 97.55,86.28 97.68,86.4 99.04,86.4 99.24,86.2 111.3,86.2 114.76,89.66 128.71,89.66 129.47,90.42 131.7,90.42 132.29,89.83 136.99,89.83 137.8,90.65 137.8,91.91 137.63,92.09 137.63,98.35 137.01,98.97 137.01,100.68 139.1,102.76 139.1,104.48 v1(139.61,104.99)
AM335X_GPMC_WPN: length 56
  TOP w0.102: U2.U17 91.38,91.38 91.38,92.9
  TOP w0.121: 91.38,92.9 91.38,93.54 92.95,95.11 93.99,95.11 94.37,95.49 96.86,95.49 98.17,96.8 102.45,96.8 104.23,98.58 112.81,98.58 114.34,100.11 129.91,100.11 130.05,100.25 132.71,102.92 137.16,102.92 137.39,102.69 137.39,102.46 137.83,102.02 139.61,102.02 R139.2
AM335X_I2C0_SCL: length 199.6
  TOP w0.102: v2(79.4,90.6) U2.C16
  TOP w0.121: R265.2 145.33,71.28 143.93,71.28 142.66,72.55 141.52,72.55 140.94,71.98 U7.6 140.94,68.76 140.52,68.34 126.02,68.34 120.41,62.73 120.41,59.81 116.97,56.36 111.92,56.36 109.14,53.58 108.9,53.58 108.65,53.33 103.36,53.33 102.85,53.83 100.82,53.83 100.55,53.56 97.1,53.56 96.85,53.82 95.95,53.82 95.56,53.43 79.34,53.43 v1(78.65,52.74) 77.48,52.74 75.73,54.49 74.36,54.49 73.46,55.4 65.68,55.4 64.27,56.81 62.32,56.81 60.24,58.89 v1(60.24,59.79) ; v1(78.68,95.08) 77.48,95.08 76.74,95.82 73.49,95.82 72.96,95.29 72.15,95.29 71.44,96 71.04,96 69.69,97.35 66.37,97.35 65.3,97.35 64.7,96.75 62.81,96.75 62.62,96.94 v1(62.01,96.94)
  LY4 w0.133: v1(80.68,25.56) 80.68,26.07 81.31,26.7 81.31,36.25 80.8,36.76 80.8,39.95 78.65,42.1 v1(78.65,52.74)
  BOTTOM w0.102: v2(79.4,90.6) 79.4,90.97 79.79,91.36 79.79,92.9
  BOTTOM w0.121: v1(60.24,59.79) 60.55,60.1 60.55,61.13 60.36,61.31 60.36,69.22 63.32,72.17 63.61,72.46 63.61,81.42 63.22,81.8 63.22,83.23 62.56,83.89 62.56,86.8 61.84,87.52 61.84,88.66 60.74,89.76 60.74,91.1 61.51,91.86 61.51,96.15 62.01,96.66 v1(62.01,96.94) ; 79.79,92.9 79.79,93.89 78.68,95 v1(78.68,95.08) 78.8,95.2 78.8,95.8 78.52,96.07 78.52,97.07 ; R551.2 81.19,25.06 v1(80.68,25.56)
AM335X_I2C0_SDA: length 210.1
  TOP w0.102: 80,92.9 80,92.47 79.41,91.88 79.41,91.39 U2.C17
  TOP w0.121: R268.2 145.33,71.03 143.8,71.03 142.66,72.17 142.4,72.17 142.21,71.98 U7.5 142.21,68.53 141.77,68.08 126.45,68.08 120.66,62.29 120.66,59.6 117.18,56.11 112.56,56.11 109.98,53.54 109.92,53.54 109.71,53.33 109,53.33 108.76,53.08 103.03,53.08 102.55,53.57 101.64,53.57 100.72,52.65 97.67,52.65 96.75,53.57 96.2,53.57 94.94,52.31 82.18,52.31 81.77,52.72 v1(79.35,52.72) 78.94,52.3 77.57,52.3 75.63,54.25 74.26,54.25 73.36,55.15 65.58,55.15 64.17,56.55 62.13,56.55 59.6,59.09 59.6,59.52 59.09,60.04 54.53,60.04 v1(54.52,60.04) ; 80,92.9 80,94.39 78.77,95.62 78.29,95.62 v1(78.27,95.64) 77.27,95.64 76.84,96.07 73.39,96.07 72.86,95.55 72.24,95.55 71.55,96.24 71.52,96.24 71.49,96.28 71.11,96.28 69.79,97.6 66.47,97.6 65.18,97.6 64.59,97.01 63.28,97.01 62.79,97.5 61.89,97.5 61.51,97.13 58.88,97.13 55.79,94.05 v1(54.52,94.05)
  LY4 w0.133: v1(81.57,25.82) 81.57,36.36 81.06,36.87 81.06,40.12 79.03,42.15 79.03,50.99 79.35,51.31 v1(79.35,52.72)
  BOTTOM w0.121: v1(78.27,95.64) 78.27,96.18 77.38,97.07 ; v1(54.52,94.05) 54.52,91.6 55.32,90.8 55.32,87.43 53.44,85.55 53.44,80.68 51.6,78.84 51.6,74.65 54.71,71.54 54.71,60.23 v1(54.52,60.04) ; R550.2 81.95,26.2 v1(81.57,25.82)
AM335X_LCD_AC_BIAS_EN: length 52.4
  TOP w0.102: v2(89.8,81.8) U2.R6
  TOP w0.121: R312.2 127.16,75.22 125.77,75.22 v1(125.77,75.21) ; v1(99.41,83.23) 99.07,83.57 97.79,83.57 v1(97.45,83.22)
  BOTTOM w0.102: v2(89.8,81.8) 90.06,81.8 90.44,81.42 90.99,81.42 91.65,80.76 93.71,80.76 93.72,80.76
  BOTTOM w0.121: v1(125.77,75.21) 124.5,75.21 124.37,75.34 124.37,77.63 125.33,78.59 125.33,79.09 125.01,79.41 124.37,79.41 123.74,80.05 123.74,83.98 122.08,85.64 120.97,85.64 120.1,84.78 120.1,84.24 119.01,83.15 106.06,83.15 105.73,83.48 99.66,83.48 v1(99.41,83.23) ; v1(97.45,83.22) 96.48,82.26 94.73,82.26 94.14,81.68 94.14,81.19 93.72,80.76
AM335X_LCD_DATA0: length 118.9
  TOP w0.102: U2.R1 89.63,77.97 89.68,77.97 90.01,77.64 90.51,77.64 90.78,77.37 91.93,77.37 91.94,77.38 92.92,77.38
  TOP w0.121: 92.92,77.38 94.53,77.38 98.11,73.79 104.92,73.79 106.46,72.26 108.82,72.26 110.28,70.8 118.11,70.8 118.32,70.59 135.81,70.59 v1(136.26,71.03) ; SW3.16 v1(162.5,69.13) ; R299.2 141.38,86.52 142.65,86.52 v1(142.66,86.52) 146.29,86.52 146.67,86.91 151.26,86.91 151.58,86.59 153.01,86.59 153.96,87.54 v1(166.53,87.54)
  BOTTOM w0.121: v1(136.26,71.03) 135.87,71.42 135.87,71.43 135.83,71.47 135.83,72.32 138.27,74.75 138.27,77.46 141.29,80.49 141.29,85.67 142.15,86.52 v1(142.66,86.52) ; v1(162.5,69.13) R96.1 164.06,69.57 164.06,72.61 164.32,72.87 165.42,72.87 166.34,73.79 166.34,84.29 166.09,84.54 166.09,86.97 166.53,87.41 v1(166.53,87.54)
AM335X_LCD_DATA1: length 115.6
  TOP w0.102: U2.R2 89.4,78.76 89.87,78.29 89.87,78.06 90.06,77.87 90.58,77.87 90.84,77.61 92.15,77.61
  TOP w0.121: SW3.15 v1(162.5,66.59) ; R300.2 141.38,87.54 142.53,87.54 v1(142.53,87.54) 143.06,88.07 153.68,88.07 153.71,88.1 161.38,88.1 v1(161.45,88.18) ; v1(135.42,71.03) 134.96,71.03 134.81,70.88 118.74,70.88 118.55,71.07 110.36,71.07 108.93,72.5 106.56,72.5 105.02,74.04 98.24,74.04 94.59,77.7 92.89,77.7 92.8,77.61 92.16,77.61 92.15,77.61
  BOTTOM w0.102: 138.02,74.85 135.6,72.43 135.6,71.51 135.42,71.33
  BOTTOM w0.121: 138.02,74.85 138.02,77.57 141.05,80.59 141.05,86.05 v1(142.53,87.54) ; R97.1 v1(162.5,66.59) 161.52,67.56 161.52,81.95 162.02,82.45 162.02,83.42 161.51,83.92 161.51,84.17 161.45,84.23 v1(161.45,88.18) ; v1(135.42,71.03) 135.42,71.33
AM335X_LCD_DATA2: length 121.9
  TOP w0.102: v2(89.8,79.4) U2.R3
  TOP w0.121: R301.2 141.38,84.11 v1(142.53,84.11) 143.83,84.11 143.9,84.17 152.63,84.17 153.96,85.51 v1(166.66,85.51) ; v1(98.08,76.24) 98.08,75.93 99.19,74.82 112.63,74.82 114.42,73.03 119.7,73.03 120.14,72.58 133.18,72.58 133.31,72.45 133.31,71.59 133.44,71.46 133.92,71.46 134.05,71.59 134.05,72.3 134.17,72.43 134.78,72.43 134.91,72.3 134.91,71.97 135.04,71.84 135.47,71.84 135.6,71.97 135.6,72.3 135.72,72.43 136.23,72.43 136.36,72.3 136.36,72.04 136.49,71.91 v1(136.79,71.91) ; SW3.14 v1(162.5,64.05)
  BOTTOM w0.102: 93,77.57 92.95,77.62 90.76,77.62 89.8,78.57 v2(89.8,79.4)
  BOTTOM w0.121: v1(162.5,64.05) R98.1 164.71,65.14 166.36,65.14 166.66,65.44 v1(166.66,85.51) ; 93,77.57 94.62,77.57 95.44,76.75 97.57,76.75 v1(98.08,76.24) ; v1(136.79,71.91) 136.81,71.91 137.23,72.33 137.23,73.01 138.76,74.54 138.76,76.09 140.9,78.22 140.9,78.86 141.79,79.76 141.79,83.63 142.15,83.98 142.41,83.98 v1(142.53,84.11)
AM335X_LCD_DATA3: length 126
  TOP w0.102: U2.R4 v2(89.8,80.2)
  TOP w0.121: v1(98.72,75.92) 99.57,75.07 112.75,75.07 113.31,74.5 113.31,74.49 114.53,73.27 119.8,73.27 120.25,72.83 136.46,72.83 136.76,72.53 v1(136.79,72.53) ; v1(166.53,86.52) 165.86,85.85 153.28,85.85 152.88,85.44 142.79,85.44 142.66,85.31 v1(142.66,85.25) 142.53,85.13 141.39,85.13 R246.2 ; SW3.13 v1(162.5,61.51)
  BOTTOM w0.102: v2(89.8,80.2) 89.8,79.94 90.18,79.56 90.18,78.99 90.22,78.96 90.22,78.44 90.44,78.22 90.45,78.22 90.85,77.82 92.93,77.82 93,77.89
  BOTTOM w0.121: v1(136.79,72.53) 136.75,72.53 136.79,72.57 136.79,72.92 138.51,74.65 138.51,76.19 140.65,78.33 140.65,78.96 141.54,79.85 141.54,84.14 v1(142.66,85.25) ; v1(166.53,86.52) 167.1,85.96 167.1,61.41 166.23,60.54 164.58,60.54 R99.1 v1(162.5,61.51) ; v1(98.72,75.92) 98.72,76.36 98.08,77 95.54,77 94.65,77.89 93,77.89
AM335X_LCD_DATA4: length 117.4
  TOP w0.102: 93,77.95 92.84,77.95 92.71,77.82 92.39,77.82 92.39,77.82 90.91,77.82 90.53,78.2 U2.T1
  TOP w0.121: SW3.12 v1(162.5,58.97) ; v1(161.58,82.97) 161.07,82.46 154.23,82.46 153.15,81.38 152.74,81.38 152.16,81.96 143.52,81.96 143,81.44 v1(142.66,81.44) 142.28,81.06 141.39,81.06 R303.2 ; v1(138.72,73.06) 137.13,71.47 134.65,71.47 134.31,71.13 119,71.13 118.81,71.32 110.6,71.32 110.48,71.45 110.48,72 110.6,72.12 112.13,72.12 112.25,72.25 112.25,72.78 112.13,72.91 106.52,72.91 106.39,73.04 106.39,74.16 106.27,74.29 98.35,74.29 94.68,77.95 93,77.95
  BOTTOM w0.121: v1(138.72,73.06) 138.9,73.24 138.9,73.24 139.16,73.5 139.16,74.17 139.26,74.26 139.26,75.88 141.39,78.02 141.39,78.65 142.66,79.92 v1(142.66,81.44) ; R100.1 v1(162.5,58.97) 161.03,60.44 161.03,78.45 160.63,78.85 160.63,81.41 161.58,82.36 v1(161.58,82.97)
AM335X_LCD_DATA5: length 120.9
  TOP w0.102: v2(90.6,78.6) U2.T2
  TOP w0.121: v1(96.11,77.51) 96.87,76.75 98.65,76.75 100.08,75.32 113.31,75.32 113.44,75.19 113.44,74.88 113.56,74.75 114.06,74.75 114.18,74.62 114.18,74.05 114.31,73.93 114.64,73.93 114.77,74.05 114.77,74.62 114.9,74.75 115.33,74.75 115.45,74.62 115.45,73.7 115.58,73.57 115.99,73.57 116.12,73.7 116.12,74.62 116.24,74.75 116.65,74.75 116.78,74.62 116.78,73.65 116.9,73.52 117.21,73.52 117.33,73.65 117.33,74.62 117.46,74.75 117.87,74.75 117.99,74.62 117.99,73.65 118.12,73.52 119.9,73.52 120.35,73.07 136.87,73.07 137.15,72.8 137.64,72.8 v1(137.68,72.83) ; v1(161.07,83.98) 159.93,82.84 153.07,82.84 152.69,82.46 v1(142.66,82.46) 142.28,82.08 141.39,82.08 R288.2 ; SW3.11 v1(162.5,56.43)
  BOTTOM w0.102: 93,78.53 92.73,78.53 92.68,78.58 92.39,78.58 92.39,78.58 91.64,78.58 91.64,78.58 91.48,78.58 91.46,78.6 v2(90.6,78.6)
  BOTTOM w0.121: v1(137.68,72.83) 137.68,73.11 139.01,74.44 139.01,75.99 141.14,78.12 141.14,78.76 142.07,79.69 142.07,81.88 v1(142.66,82.46) ; 93,78.53 93.3,78.24 95.38,78.24 v1(96.11,77.51) ; v1(161.07,83.98) 161.07,82.2 160.38,81.51 160.38,78.75 160.78,78.35 160.78,58.14 v1(162.5,56.43) R101.1
AM335X_LCD_DATA6: length 128.9
  TOP w0.102: v2(90.6,79.4) U2.T3
  TOP w0.121: R289.2 127.16,77.25 125.63,77.25 125.57,77.31 124.94,77.31 v1(124.88,77.38) 124.88,78.23 124.75,78.35 124.32,78.35 124.19,78.23 124.19,77.18 124.07,77.05 114.26,77.05 114.13,77.18 114.13,77.63 114.26,77.76 123.28,77.76 123.4,77.89 123.4,78.32 123.28,78.45 113.4,78.45 113.27,78.32 113.27,76.75 113.14,76.62 112.69,76.62 112.56,76.75 112.56,77.58 112.43,77.71 112.05,77.71 111.92,77.58 111.92,76.75 111.8,76.62 111.21,76.62 111.09,76.75 111.09,77.58 110.96,77.71 110.36,77.71 110.23,77.58 110.23,76.75 110.1,76.62 109.64,76.62 109.51,76.75 109.51,77.58 109.38,77.71 108.98,77.71 108.74,77.46 108.74,76.58 108.46,76.31 102.1,76.31 101.83,76.58 100.35,76.58 99.41,77.51 99.41,78.72 v1(99.61,78.91) ; v1(131.36,60.74) 137.32,60.74 137.95,61.37 150.54,61.37 151.65,60.26 158.15,60.26 161.84,56.57 161.84,54.55 v1(162.5,53.89) SW3.10
  BOTTOM w0.102: 93,78.78 93,78.78 92.62,78.78 92,79.4 v2(90.6,79.4)
  BOTTOM w0.121: v1(99.61,78.91) 99.09,78.4 97.83,78.4 97.44,78.78 97.07,78.78 96.81,78.52 93.36,78.52 93.1,78.78 93,78.78 ; R102.1 v1(162.5,53.89) ; v1(124.88,77.38) 124.88,76.36 125.45,75.8 125.83,75.8 126.4,75.22 127.67,75.22 128.04,74.85 128.04,74.59 131.36,71.28 v1(131.36,60.74)
AM335X_LCD_DATA7: length 135.3
  TOP w0.102: v2(90.6,80.2) U2.T4
  TOP w0.121: SW3.9 v1(162.5,51.35) 161.58,52.26 161.58,56.48 158.06,59.99 151.51,59.99 150.38,61.12 138.59,61.12 137.19,59.72 129.77,59.72 128.02,61.47 128.02,63.3 v1(128.56,63.84) ; R290.2 127.16,82.33 125.39,82.33 125.39,82.33 v1(122.97,82.33) 122.97,82.79 122.57,83.2 120.66,83.2 120.53,83.07 120.53,82.74 120.66,82.61 121.53,82.61 121.65,82.49 121.65,82.08 121.53,81.95 115.05,81.95 114.92,82.08 114.92,82.43 115.05,82.56 119.72,82.56 119.85,82.69 119.85,83.07 119.72,83.2 114.62,83.2 112.86,81.44 107.83,81.44 107.71,81.32 107.71,80.86 107.83,80.73 111.54,80.73 111.67,80.61 111.67,80.17 111.54,80.05 108.06,80.05 107.94,79.92 107.94,77.19 107.81,77.07 102.97,77.07 v1(102.65,77.38)
  BOTTOM w0.102: 93,80.02 90.79,80.02 90.61,80.2 v2(90.6,80.2)
  BOTTOM w0.121: 93,80.02 95.61,80.02 95.8,79.83 96.37,79.83 96.47,79.93 98.26,79.93 98.59,79.6 99.89,79.6 100.29,79.19 100.29,78.99 100.29,78.72 100.95,78.07 101.96,78.07 v1(102.65,77.38) ; v1(122.97,82.33) 122.97,70.9 128.05,65.82 128.05,64.35 v1(128.56,63.84) ; R103.1 v1(162.5,51.35)
AM335X_LCD_DATA8: length 140.6
  TOP w0.102: U2.U1 91.15,78.2 91.6,78.65 92.68,78.65
  TOP w0.121: R262.2 127.16,80.3 125.45,80.3 125.32,80.17 125.32,79.67 124.94,79.29 v1(123.86,79.29) ; SW4.16 v1(162.47,91.73) ; 92.68,78.65 92.73,78.6 94.38,78.6 98.45,74.54 112.56,74.54 112.69,74.41 112.69,74.05 112.56,73.93 106.77,73.93 106.64,73.8 106.64,73.29 106.77,73.16 112.56,73.16 112.69,73.04 112.69,72.73 112.82,72.6 113.3,72.6 113.42,72.73 113.42,72.97 113.55,73.09 114.01,73.09 114.13,72.97 114.13,72.38 114.26,72.25 115.53,72.25 115.66,72.12 116.32,72.12 116.45,72.25 116.45,72.65 116.58,72.78 117.03,72.78 117.16,72.65 117.16,71.7 117.28,71.57 117.72,71.57 117.84,71.7 117.84,72.65 117.97,72.78 118.38,72.78 118.5,72.65 118.5,71.7 118.63,71.57 v1(123.83,71.57) ; v1(159.93,63.28) 159.07,63.28 158.48,62.69 153.12,62.69 152.78,63.04 138.11,63.04 137.92,63.22 134.86,63.22 134.73,63.34 129.87,63.34 v1(128.56,64.65)
  BOTTOM w0.121: R104.1 v1(162.47,91.73) 159.89,89.15 159.89,78.54 159.93,78.5 v1(159.93,63.28) ; v1(128.56,64.65) 128.56,65.95 127.67,66.84 127.67,70.01 126.12,71.57 v1(123.83,71.57) 123.83,72.33 123.86,72.36 v1(123.86,79.29)
AM335X_LCD_DATA9: length 154
  TOP w0.102: 93,79.1 92.97,79.13 92.75,79.13 92.53,79.35 91.41,79.35 91.07,79 U2.U2
  TOP w0.121: v1(99.86,77.7) 100.73,76.82 101.96,76.82 102.23,76.55 108.36,76.55 108.49,76.68 108.49,79.27 108.62,79.39 109.03,79.39 109.16,79.27 109.16,78.22 109.28,78.09 109.74,78.09 109.86,78.22 109.86,79.27 109.99,79.39 110.4,79.39 110.53,79.27 110.53,78.22 110.65,78.09 111.01,78.09 111.14,78.22 111.14,79.27 111.26,79.39 111.7,79.39 111.82,79.27 111.82,78.22 111.95,78.09 112.51,78.09 112.64,78.22 112.64,79.93 112.76,80.05 123.05,80.05 123.18,79.93 123.18,79.51 123.05,79.39 113.52,79.39 113.4,79.26 113.4,78.9 113.52,78.78 v1(124.88,78.78) 125.39,78.27 127.16,78.27 R266.2 ; v1(160.31,61.63) 159.22,60.54 151.83,60.54 150.74,61.63 v1(128.82,61.63) ; SW4.15 v1(162.47,89.19) ; 93,79.1 94.68,79.1 95.51,78.27 96.68,78.27 v1(97.32,77.63)
  BOTTOM w0.121: v1(97.32,77.63) 97.83,77.63 97.89,77.7 v1(99.86,77.7) ; v1(124.88,78.78) 124.12,78.02 124.12,75.25 125.47,73.89 126.21,73.89 126.78,73.32 126.78,72.17 127.16,71.79 127.8,71.79 128.05,71.54 128.05,66.97 129.07,65.95 129.07,61.89 v1(128.82,61.63) ; R105.1 v1(162.47,89.19) 161.85,89.19 160.14,87.48 160.14,78.64 160.37,78.41 160.37,63.1 160.31,63.04 v1(160.31,61.63)
AM335X_LCD_DATA10: length 96.9
  TOP w0.102: 93,80.17 91.41,80.17 91.04,79.8 U2.U3
  TOP w0.121: R294.2 141.52,78.9 v1(142.66,78.9) 142.66,78.9 147.24,78.9 147.87,78.27 150.09,78.27 150.34,78.02 v1(161.96,78.02) ; 93,80.17 94.4,80.17 94.99,79.58 v1(95.41,79.58) ; v1(104.16,73.09) 105.31,71.94 108.72,71.94 108.85,71.82 108.85,70.68 108.98,70.55 117.48,70.55 117.7,70.34 136.35,70.34 138.44,72.43 v1(138.72,72.43) ; SW4.14 v1(162.47,86.65)
  BOTTOM w0.121: v1(104.16,73.09) 104.16,74.66 101.89,76.94 101.89,77.12 101.18,77.82 100.82,77.82 100.82,77.82 100.05,78.59 100.05,79.09 99.79,79.35 98.49,79.35 98.17,79.67 96.56,79.67 96.48,79.58 v1(95.41,79.58) ; v1(138.72,72.43) 138.92,72.43 139.17,72.67 139.17,73.13 139.74,73.7 139.74,75.54 142.66,78.46 v1(142.66,78.9) ; v1(161.96,78.02) 161.96,78.56 161.78,78.75 161.78,81.86 162.27,82.35 162.27,83.52 162.03,83.76 162.03,86.21 v1(162.47,86.65) R106.1
AM335X_LCD_DATA11: length 97.3
  TOP w0.102: U2.U4 91.01,80.6 91.41,81 91.86,81 91.93,80.93 91.94,80.93 92.19,80.68 92.59,80.68
  TOP w0.121: v1(98.72,80.81) 98.72,80.43 98.46,80.17 98.46,77.38 100.28,75.56 113.56,75.56 113.68,75.44 113.68,75.13 113.81,75 118.18,75 118.31,74.87 118.31,73.9 118.43,73.77 120,73.77 120.45,73.32 138.36,73.32 138.54,73.5 139.53,73.5 139.61,73.42 v1(139.61,72.94) ; v1(95.29,81) 94.84,81 94.53,80.68 92.59,80.68 ; v1(162.34,75.35) 160.18,77.51 150.15,77.51 150.09,77.57 v1(142.66,77.57) 142.17,77.57 142.11,77.63 141.38,77.63 R267.2 ; SW4.13 v1(162.47,84.11)
  BOTTOM w0.121: R107.1 v1(162.47,84.11) 162.47,83.67 162.52,83.62 162.52,82.24 162.03,81.75 162.03,78.85 162.4,78.47 162.4,77.57 162.03,77.19 162.03,76.04 162.34,75.73 v1(162.34,75.35) ; v1(98.72,80.81) 98.71,80.81 98.46,80.56 96.86,80.56 96.42,81 v1(95.29,81) ; v1(142.66,77.57) 142.15,77.57 140.25,75.67 140.25,73.57 v1(139.61,72.94)
AM335X_LCD_DATA12: length 87.5
  TOP w0.102: U2.V2 92.57,79 ; 138.04,80.81 135.17,80.81
  TOP w0.121: 138.04,80.81 138.9,80.81 139.16,80.55 139.16,80.49 139.61,80.05 140.37,80.05 R257.2 141.38,80.05 146.38,80.05 146.76,80.43 161.33,80.43 v1(162.47,81.57) SW4.12 ; v1(134.28,80.17) 134.91,80.81 135.17,80.81 ; 92.57,79 92.66,78.91 92.8,78.91 92.87,78.85 94.58,78.85 95.48,77.95 96.38,77.95 97.14,77.19 97.51,77.19 98.21,77.89 98.21,81.63 v1(97.89,81.95)
  BOTTOM w0.102: 133.59,80.86 133.56,80.83 131.8,80.83 131.79,80.82 131.02,80.82 131.01,80.83 130.97,80.83 130.72,81.09 130.72,81.13
  BOTTOM w0.121: 130.72,81.13 130.66,81.19 130.66,81.25 129.8,82.11 129.31,82.11 129.05,82.37 129.05,82.41 127.92,83.53 127.36,83.53 126.76,84.14 126.76,86.3 126.67,86.38 117.97,86.38 115.47,83.89 106.37,83.89 106.03,84.22 99.08,84.22 98.18,83.33 98.18,82.97 97.89,82.68 v1(97.89,81.95) ; v1(134.28,80.17) 133.59,80.86 ; R108.1 v1(162.47,81.57)
AM335X_LCD_DATA13: length 127.8
  TOP w0.102: U2.V3 92.65,79.8
  TOP w0.121: v1(97.26,78.33) 97,78.59 95.54,78.59 94.33,79.8 93.17,79.8 93.07,79.9 92.74,79.9 92.65,79.8 ; v1(132.13,62.85) 132.18,62.9 137.45,62.9 137.56,62.79 152.68,62.79 153.02,62.44 158.66,62.44 158.86,62.65 161.45,62.65 v1(161.84,62.27) ; SW4.11 v1(162.47,79.03) v1(161.07,79.03) ; R283.2 127.17,81.32 126.45,81.32 126.4,81.36 125.69,81.36 v1(125.13,80.81) 125.13,81.8 125.01,81.93 124.5,81.93 124.37,81.8 124.37,80.48 124.24,80.35 123.89,80.35 123.76,80.48 123.76,81.52 123.63,81.65 119.59,81.65 119.47,81.52 119.47,81.06 119.59,80.94 122.8,80.94 122.92,80.81 122.92,80.43 122.8,80.3 112.25,80.3 112.13,80.17 112.13,79.77 112,79.64 108.37,79.64 108.24,79.51 108.24,76.93 108.11,76.8 102.53,76.8 101.95,77.38 101.95,78.29 101.83,78.42 101.15,78.42 101.03,78.29 101.03,77.41 v1(101,77.38)
  BOTTOM w0.121: v1(161.84,62.27) 161.84,63.04 161.27,63.6 161.27,78.83 v1(161.07,79.03) ; v1(132.13,62.85) 132.13,71.91 128.64,75.4 128.64,77.94 127.8,78.78 127.8,79.67 127.16,80.3 125.64,80.3 v1(125.13,80.81) ; v1(101,77.38) 100.56,77.38 100.3,77.64 100.3,77.88 100.04,78.14 97.45,78.14 v1(97.26,78.33) ; v1(162.47,79.03) R109.1
AM335X_LCD_DATA14: length 91
  TOP w0.102: 135.17,78.27 137.86,78.27 138.04,78.09 ; U2.V4 91.97,80.43 93.22,80.43
  TOP w0.121: v1(134.53,78.4) 135.04,78.4 135.17,78.27 ; SW4.10 v1(162.47,76.49) 161.55,76.49 160.28,77.76 150.25,77.76 149.99,78.02 142.36,78.02 142.23,77.89 141.38,77.89 R260.2 140.25,77.76 139.61,77.76 139.41,77.96 138.16,77.96 138.04,78.09 ; 93.22,80.43 95.38,80.43 95.8,80.85 95.8,81.06 97.19,82.46 98.59,82.46 v1(98.72,82.59)
  BOTTOM w0.121: v1(98.72,82.59) 98.72,83.16 98.72,83.16 98.72,83.51 99.18,83.97 105.93,83.97 106.26,83.64 115.63,83.64 118.12,86.14 126.3,86.14 126.43,86.01 126.43,83.53 128.69,81.26 128.69,81.01 128.94,80.76 128.94,79.54 129.42,79.06 129.42,76.01 131.09,74.35 133.76,74.35 134.59,75.18 134.59,77.9 134.53,77.95 v1(134.53,78.4) ; R110.1 v1(162.47,76.49)
AM335X_LCD_DATA15: length 125.4
  TOP w0.102: v2(90.6,81) U2.T5
  TOP w0.121: v1(135.04,63.66) 137.83,63.66 138.21,63.28 142.39,63.28 142.83,63.72 152.63,63.72 153.41,62.94 158.1,62.94 158.89,63.72 160.11,63.72 160.43,63.41 v1(162.09,63.41) ; R285.2 126.98,84.55 125.33,84.55 125.24,84.64 125.24,84.98 125.39,85.13 127.16,85.13 v1(127.67,84.62) ; v1(164.5,72.43) 164.5,73.7 SW4.9 v1(162.47,73.95)
  BOTTOM w0.095: 133.64,83.35 133.59,83.35
  BOTTOM w0.102: 92.97,80.52 91.58,80.52 91.1,81 v2(90.6,81) ; 130.72,83.48 130.85,83.35 133.59,83.35
  BOTTOM w0.121: v1(164.5,72.43) 166.41,70.52 166.41,65.65 166.2,65.44 162.04,65.44 161.78,65.18 161.78,63.72 v1(162.09,63.41) ; v1(135.04,63.66) 135.04,69.86 134.83,70.06 134.83,71.56 135.04,71.77 135.04,82.71 134.4,83.35 133.64,83.35 ; 130.72,83.48 130.59,83.6 130.59,84.37 130.34,84.62 v1(127.67,84.62) 127.67,85.17 127.79,85.29 128.52,85.29 128.64,85.41 128.64,85.66 128.52,85.78 127.79,85.78 127.67,85.9 127.67,86.17 126.96,86.88 115.6,86.88 112.85,84.14 106.47,84.14 106.14,84.47 98.97,84.47 97.89,83.38 97.89,83.03 97.54,82.68 96.87,82.01 94.84,82.01 94.53,81.7 94.53,81.09 93.95,80.52 92.97,80.52 ; v1(162.47,73.95) R111.1
AM335X_LCD_HSYNC: length 67.9
  TOP w0.102: v2(89.8,81) U2.R5
  TOP w0.121: R311.2 127.67,74.38 127.85,74.21 133.43,74.21 133.68,73.96 133.68,73.79 133.46,73.57 125.21,73.57 125.01,73.77 125.01,74.99 124.76,75.25 124.11,75.25 123.99,75.13 123.99,74.35 123.86,74.23 123.62,74.23 123.5,74.35 123.5,75.13 123.38,75.25 123.14,75.25 123.02,75.13 123.02,74.35 122.9,74.23 122.66,74.23 122.54,74.35 122.54,75.13 122.42,75.25 122.18,75.25 122.06,75.13 122.06,74.35 121.93,74.23 121.69,74.23 121.57,74.35 121.57,75.13 121.45,75.25 121.21,75.25 121.09,75.13 121.09,74.35 120.97,74.23 120.73,74.23 120.61,74.35 120.61,75.13 120.49,75.25 120.25,75.25 120.12,75.13 120.12,74.35 120,74.23 119.76,74.23 119.64,74.35 119.64,75.13 119.52,75.25 119.28,75.25 119.16,75.13 119.16,74.35 119.04,74.23 118.8,74.23 118.68,74.35 118.68,75.13 118.56,75.25 114.06,75.25 113.93,75.37 113.93,75.68 113.8,75.81 100.41,75.81 98.72,77.51 98.72,79.16 99.09,79.54 v1(99.09,80.18)
  BOTTOM w0.102: 93.29,80.27 91.13,80.27 90.78,80.62 90.18,80.62 v2(89.8,81)
  BOTTOM w0.121: 93.29,80.27 95.71,80.27 95.91,80.07 96.27,80.07 96.37,80.17 99.09,80.17 v1(99.09,80.18)
AM335X_LCD_PCLK: length 71
  TOP w0.102: 93,81.58 92.81,81.4 92.75,81.33 92.75,81.16 92.52,80.94 92.26,80.94 U2.V5
  TOP w0.121: 93,81.58 93.07,81.66 93.44,81.66 93.52,81.57 v1(95.03,81.57) ; R307.2 127.17,76.24 126.34,76.24 126.34,76.24 v1(125.89,76.24) 125.08,76.24 124.95,76.11 124.95,75.68 124.83,75.55 114.54,75.55 114.41,75.68 114.41,76.03 114.54,76.16 124.04,76.16 124.17,76.29 124.17,76.64 124.04,76.77 113.83,76.77 113.7,76.64 113.7,76.19 113.58,76.06 101.82,76.06 101.7,76.19 101.7,76.2 101.57,76.33 100.24,76.33 99.03,77.54 99.03,79.09 99.38,79.44 100.04,79.44 100.16,79.31 100.16,78.95 100.29,78.83 102.78,78.83 102.91,78.95 102.91,79.34 102.78,79.46 101.05,79.46 100.93,79.59 100.93,80.58 100.57,80.94 v1(99.41,80.94)
  BOTTOM w0.121: v1(95.03,81.57) 96.81,81.57 97.47,80.92 98.2,80.92 98.53,81.25 99.1,81.25 v1(99.41,80.94)
AM335X_LCD_VSYNC: length 70.8
  TOP w0.102: 133.59,79.46 133.51,79.54 130.72,79.54 ; 93,82.22 92.4,82.22 92.01,81.83 91.35,81.83 91,81.47 U2.U5 ; 137.72,74.47 138,74.47
  TOP w0.121: 130.72,79.54 130.34,79.54 130.09,79.29 126.53,79.29 v1(126.02,79.79) ; 137.72,74.47 135.47,74.47 134.27,74.47 133.83,74.91 133.83,79.22 133.59,79.46 ; 93,82.22 94.21,82.22 94.42,82.01 95.98,82.01 96.75,82.78 97.63,82.78 97.88,83.03 98.93,83.03 v1(99.4,82.56) ; R271.2 140.88,73.82 140.75,73.7 140.05,73.7 139.93,73.82 139.93,74.37 139.83,74.46 139.65,74.46 139.5,74.62 138.15,74.62 138,74.47
  BOTTOM w0.121: v1(126.02,79.79) 125.89,79.67 124.47,79.67 123.98,80.15 123.98,84.95 124.11,85.08 126.05,85.08 126.18,85.2 126.18,85.76 126.05,85.89 118.3,85.89 115.8,83.39 106.16,83.39 105.83,83.73 99.28,83.73 98.97,83.41 98.97,83 v1(99.4,82.56)
AM335X_MCASP0_ACLKR: length 41.7
  TOP w0.102: 77.1,88 77.75,87.35 78.65,87.35 U2.B12
  TOP w0.121: 77.1,88 76.43,88.67 75.49,88.67 74.51,89.65 69.36,89.65 68.03,90.97 66.33,90.97 v1(66.14,91.16) ; R379.2 v1(77.25,105.83) 76.3,105.83 75.67,106.46 71.03,106.46 69.73,105.16 v1(66.3,105.16)
  BOTTOM w0.121: v1(66.14,91.16) 66.14,91.6 66.07,91.67 66.07,99.3 66.25,99.49 66.25,102.05 66.66,102.46 66.66,104.8 v1(66.3,105.16)
AM335X_MCASP0_ACLKX: length 82.7
  TOP w0.102: 77.1,88.35 77.65,87.8 U2.A13
  TOP w0.121: v1(61.7,124.56) 63.73,124.56 64.68,123.61 67.66,123.61 67.98,123.29 69.59,123.29 70.5,124.2 76.72,124.2 v1(76.94,123.99) ; v1(66.76,91.42) 66.77,91.41 67.94,91.41 69.46,89.89 74.65,89.89 75.62,88.92 76.53,88.92 77.1,88.35 ; v1(76.62,129.7) 81.63,129.7 84.68,132.75 v1(85.84,132.75) 85.84,132.68 R448.1
  BOTTOM w0.121: v1(61.7,124.56) 61.7,122.85 66.46,118.08 66.46,106.02 67.01,105.47 67.16,105.32 67.16,102.26 66.75,101.85 66.75,99.28 66.65,99.18 66.65,93.03 67,92.68 67,91.61 66.8,91.42 v1(66.76,91.42) ; v1(76.94,123.99) 76.3,124.62 76.3,129.39 v1(76.62,129.7)
AM335X_MCASP0_AHCLKR: length 88.3
  TOP w0.102: v2(80.2,87.4) U2.C12
  TOP w0.121: R85.2 v1(85.66,156.27)
  LY4 w0.133: v1(69.2,91.47) 69.2,91.45 69.62,91.03 70.04,91.03 71.5,92.49 71.5,94.87 71.5,94.87 71.5,95.24 71.5,95.25 71.5,98.06 71.41,98.14 71.41,114.21 79.54,122.34 79.54,123.67 78.71,124.5 78.71,135.29 79.61,136.18 79.61,140.49 79.47,140.63 79.47,142.59 79.61,142.72 79.61,150.22 v1(85.66,156.27)
  BOTTOM w0.102: 77.1,88.24 77.32,88.24 78.52,87.03 79.86,87.03 80.2,87.38 v2(80.2,87.4)
  BOTTOM w0.121: 77.1,88.24 73.05,88.24 71.7,89.58 71.07,89.58 69.87,90.78 69.57,90.78 69.18,91.17 69.18,91.45 v1(69.2,91.47)
AM335X_MCASP0_AHCLKX: length 60.2
  TOP w0.102: U2.A14 77.55,88.6 77.1,89.05
  TOP w0.121: 77.1,89.05 76.74,89.41 75.86,89.41 74.88,90.39 70.26,90.39 69.87,90.78 68.93,90.78 67.85,91.86 66.19,91.86 64.86,93.19 64.46,93.19 63.84,93.82 62.45,93.82 61.44,92.81 59.03,92.81 58.84,93 v1(57.31,93) ; R352.1 47.54,113.96 47.99,113.96 48.42,114.38 48.42,114.46 48.42,114.46 48.42,115.1 49.26,115.94 57.79,115.94 58.09,115.63 v1(58.53,115.63)
  BOTTOM w0.121: v1(57.31,93) 57.31,94.02 57.57,94.27 57.57,108.88 58.85,110.16 58.85,114.98 58.84,114.98 58.84,115.32 v1(58.53,115.63)

# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_LAYOUT_REV1_6A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EXP_GPMC_CLK: length 9.7
  TOP w0.121: R181.1 123.55,95.03 124.04,95.52 126.4,95.52 127.31,96.43 J4.23
EXP_GPMC_CS0N: length 13.1
  TOP w0.121: R183.1 138.47,96.43 138.47,96.18 137.31,95.02 132.69,95.02 132.06,94.39 132.06,93.68 131.9,93.52 129.7,93.52 129.33,93.89 J4.25
EXP_GPMC_CS3N: length 9.7
  BOTTOM w0.121: J5.4 93.89,138.14 93.76,138.01 92.77,138.01 92.65,138.14 92.65,142.58 92.77,142.71 93.1,142.71 93.23,142.58 93.23,141.52 93.36,141.39 R187.1
EXP_GPMC_OEN_REN: length 79.4
  TOP w0.121: v1(137.58,104.56) 137.96,104.18 R189.1 ; v1(139.23,127.67) 138.03,127.67 137.64,128.06 137.64,128.52 137.1,129.06 136.73,129.06 134.69,131.1 131.61,131.1 129.83,132.88 120.18,132.88 118.78,134.28 109.89,134.28 106.29,137.88 100.06,137.88 99.48,138.47 97.54,138.47 97.42,138.35 92.61,138.35 J5.6
  BOTTOM w0.121: v1(139.23,127.67) 138.34,126.78 138.34,126.48 138.09,126.23 138.09,118.23 137.45,117.59 137.45,110.06 138.34,109.18 138.34,105.57 137.58,104.81 v1(137.58,104.56)
EXP_GPMC_WAIT: length 13.9
  TOP w0.121: R179.1 139.1,103.11 138.61,103.61 137.5,103.61 136.17,104.94 132.75,104.94 132.24,104.43 132.24,103.54 130.21,101.51 J4.19
EXP_GPMC_WEN: length 81.1
  TOP w0.121: R191.1 v1(137.58,105.57) ; v1(138.21,128.43) 138.21,128.43 137.96,128.69 137.96,128.69 137.34,129.31 136.83,129.31 134.78,131.36 131.74,131.36 129.89,133.2 120.37,133.2 118.97,134.6 110.03,134.6 106.46,138.16 100.57,138.16 99.88,138.85 97.57,138.85 97.32,138.59 95.67,138.59 95.29,138.98 95.29,140.12 94.78,140.63 89.83,140.63 J5.8
  BOTTOM w0.121: v1(138.21,128.43) 138.21,127.67 138.09,127.55 138.09,126.58 137.84,126.33 137.84,118.33 137.21,117.7 137.21,109.96 138.09,109.08 138.09,106.59 137.58,106.08 v1(137.58,105.57)
EXP_GPMC_WPN: length 12.7
  TOP w0.121: R180.1 137.05,101.51 136.17,102.4 132.89,102.4 130.55,100.05 129.47,98.97 J4.21
EXP_I2C1_SCL: length 2.1
  TOP w0.121: R176.1 131.36,96.43 J3.24
EXP_I2C1_SDA: length 102
  TOP w0.121: v1(68.43,94.78) R177.2
  LY3 w0.133: v1(68.36,112.38) 68.36,112.41 68.9,112.94 76.49,112.94 77.13,113.58 81.39,113.58 81.88,114.06 84.72,114.06 84.92,114.26 91.4,114.26 92.44,113.22 99.58,113.22 101.15,111.64 108.22,111.64 109.16,110.7 119.24,110.7 119.8,110.15 v1(121,110.15)
  BOTTOM w0.121: J3.23 134.6,96.43 133.65,97.38 125.25,97.38 124.52,96.66 123.13,96.66 122.08,97.7 122.08,109.07 v1(121,110.15) ; v1(68.36,112.38) 68.36,107.28 68.7,106.94 68.7,104.26 68.69,104.26 68.69,101.58 68.26,101.15 68.26,98.65 68.17,98.56 68.17,95.03 68.42,94.78 v1(68.43,94.78)
EXP_MII1_COL: length 72.5
  TOP w0.121: R231.1 82.14,100.67 v1(82.42,100.39) ; J5.34 55.79,139.64 56.71,140.56 82.98,140.56 83.23,140.81 83.95,140.81 v1(84.17,141.03)
  BOTTOM w0.121: v1(84.17,141.03) 84.57,140.63 84.57,140.11 84.68,140 84.68,131.01 84.05,130.38 84.05,121.77 82.51,120.23 82.51,119.75 81.27,118.51 81.27,106.86 81.96,106.17 81.96,101.41 82.42,100.94 v1(82.42,100.39)
EXP_MII1_CRS: length 6.9
  TOP w0.121: R235.1 v1(52.21,134.15)
  BOTTOM w0.121: J5.36 52.21,138.57 v1(52.21,134.15)
EXP_MII1_RXERR: length 66
  TOP w0.121: v1(52.18,108.67) 52.5,108.98 65.99,108.98 66.2,109.19 78.77,109.19 78.91,109.05 80.5,107.46 80.5,106.79 81.68,105.62 81.68,105.05 82.17,104.56 R237.1
  BOTTOM w0.121: J5.38 51.73,138.59 51.73,135.9 51.04,135.22 51.04,117.66 51.8,116.9 51.8,109.79 52.18,109.41 v1(52.18,108.67)
EXP_MMC0_CLK: length 3
  BOTTOM w0.121: R197.1 83.6,139.74 J5.12
EXP_MMC0_CMD: length 2.9
  BOTTOM w0.121: R200.1 J5.14
EXP_MMC0_DAT0: length 2.8
  BOTTOM w0.121: J5.16 R204.1
EXP_MMC0_DAT1: length 2.8
  BOTTOM w0.121: R212.1 J5.22
EXP_MMC0_DAT2: length 2.8
  BOTTOM w0.121: J5.24 R215.1
EXP_MMC0_DAT3: length 3.2
  BOTTOM w0.121: R219.1 66.97,140.63 J5.26
EXP_MMC1_CLK: length 49.2
  TOP w0.121: v1(137.36,91.73) 136.94,91.73 136.69,91.47 136.69,90.86 136.29,90.46 132.89,90.46 132.01,91.35 129.43,91.35 128.55,90.46 125.13,90.46 123.6,91.99 117.42,91.99 115.54,90.11 108.34,90.11 108.34,90.11 106.62,90.11 106.62,90.11 102.4,90.11 100.88,88.58 R175.2
  BOTTOM w0.121: v1(137.36,91.73) 137.38,91.75 137.38,97.39 J3.21
EXP_MMC1_CMD: length 38.8
  TOP w0.121: R173.2 102.1,92.75 104.89,95.54 121.64,95.54 123.48,97.38 v1(123.48,97.39)
  BOTTOM w0.121: J3.19 134.21,99.92 134.21,98.58 133.51,97.87 123.97,97.87 v1(123.48,97.39)
EXP_MMC1_DAT0: length 5.1
  TOP w0.121: R171.2 v1(137.58,106.84)
  BOTTOM w0.121: v1(137.58,106.84) 136.94,106.21 136.94,105.19 J3.17
EXP_MMC1_DAT1: length 4
  TOP w0.121: R169.2 137.45,108.24 J3.15
EXP_MMC1_DAT2: length 3.5
  TOP w0.121: J3.13 136.31,109.64 R167.2
EXP_MMC1_DAT3: length 3.6
  TOP w0.121: R165.2 137.96,110.91 137.2,111.67 J3.11
EXP_MMC1_DAT4: length 4.1
  TOP w0.121: J3.9 137.07,114.21 R163.2
EXP_MMC1_DAT5: length 4.6
  TOP w0.121: R161.2 137.2,115.48 137.07,115.48 J3.7
EXP_MMC1_DAT6: length 5.7
  TOP w0.121: R159.2 137.1,116.98 137.1,117.99 J3.5
EXP_MMC1_DAT7: length 7
  TOP w0.121: R157.2 137.77,117.58 137.77,119.73 135.8,121.7 J3.3
EXP_PB_POWERON: length 189.5
  TOP w0.203: v1(155.46,123.23) 149.17,123.23 148.79,122.85 144.8,122.85 144,122.05 142.2,122.05 141.4,122.85 135.18,122.85 134.68,122.34 134.68,118.86 133.97,118.15 133.26,118.15 129.11,113.99 129.11,113.74 128.33,112.97 126.94,112.97 J4.12 ; v1(96.27,52.86) 96.94,52.86 97.16,52.64 97.17,52.64 97.45,52.36 100.88,52.36 101.76,53.25 102.4,53.25 102.86,52.79 108.88,52.79 109.13,53.04 109.83,53.04 110.04,53.25 116.29,53.25 120.51,57.47 121.79,57.47 122.94,58.62 128.89,58.62 128.96,58.55 131.39,58.55 132.88,57.06 140.97,57.06 142.24,58.33 150.66,58.33 151.68,57.31 v1(158.15,57.31)
  BOTTOM w0.203: v1(155.46,123.23) 155.46,98.87 157.9,96.43 157.9,57.57 v1(158.15,57.31) ; v1(96.27,52.86) 96.27,44.99 94.83,43.55 88.15,43.55 87.79,43.19 R63.2
EXP_RMII1_REFCLK: length 71.7
  BOTTOM w0.121: J5.3 92.44,137.07 92.32,137.2 92.32,145.31 92.44,145.44 93.41,145.44 93.53,145.57 93.53,145.8 93.41,145.92 93.01,145.92 92.89,146.04 92.89,146.29 93.01,146.41 93.84,146.41 93.97,146.53 93.97,146.76 93.84,146.89 93.01,146.89 92.89,147.01 92.89,147.74 93.01,147.87 94.78,147.87 94.91,147.74 94.91,144.37 95.03,144.37 95.28,144.11 95.28,143.75 95.09,143.55 95.09,136.14 94.91,135.96 94.91,134.88 95.15,134.63 95.15,134.36 95.41,134.1 95.41,133.69 95.12,133.39 95.06,133.39 94.91,133.24 94.91,133.07 94.78,132.94 94.78,131.36 94.79,131.35 94.79,131.09 95.23,130.65 95.23,128.7 94.78,128.24 94.78,124.18 94.27,123.67 94.27,122.21 95.03,121.45 95.03,120.05 94.78,119.8 93.76,119.8 93.51,120.05 93.51,123.99 93.63,124.11 94.28,124.11 94.4,124.23 94.4,124.47 94.28,124.59 93.63,124.59 93.51,124.71 93.51,124.95 93.63,125.07 94.28,125.07 94.4,125.2 94.4,125.44 94.28,125.56 93.63,125.56 93.51,125.68 93.51,125.92 93.63,126.04 94.28,126.04 94.4,126.16 94.4,126.4 94.28,126.52 93.63,126.52 93.51,126.64 93.51,126.88 93.63,127.01 94.28,127.01 94.4,127.13 94.4,127.37 94.28,127.49 93.63,127.49 93.51,127.61 93.51,127.85 93.63,127.97 94.28,127.97 94.4,128.09 94.4,128.33 94.28,128.45 93.63,128.45 93.45,128.63 93.45,130.4 93.14,130.71 93.14,133.86 93.57,134.29 93.57,134.59 R188.2
EXP_SPI0_CLK: length 103.6
  TOP w0.121: R201.2 70.52,94.58 70.29,94.81 v1(70.29,95.06) ; J5.13 81.19,138.34 81,138.53 80.24,138.53 80.05,138.34 80.05,136.37 79.92,136.24 79.35,136.24 79.22,136.12 79.22,136.02 78.74,135.54 78.73,135.54 78.67,135.48 78.04,135.48 77.91,135.61 77.91,136.34 77.63,136.62 77.63,137.89 77.76,138.02 79.35,138.02 79.48,138.15 79.48,138.47 79.35,138.59 77.06,138.59 76.94,138.47 76.94,138.39 76.82,138.27 76.58,138.27 76.46,138.39 76.46,138.47 76.33,138.59 76.09,138.59 75.97,138.47 75.97,138.39 75.85,138.27 75.61,138.27 75.49,138.39 75.49,138.47 75.37,138.59 75.13,138.59 75.01,138.47 75.01,138.39 74.89,138.27 74.65,138.27 74.52,138.39 74.52,138.47 74.4,138.59 74.16,138.59 74.04,138.47 74.04,138.39 73.92,138.27 73.68,138.27 73.56,138.39 73.56,138.47 73.44,138.59 73.2,138.59 73.08,138.47 73.08,138.39 72.96,138.27 72.71,138.27 72.59,138.39 72.59,138.47 72.47,138.59 72.23,138.59 72.11,138.47 72.11,138.39 71.99,138.27 71.75,138.27 71.63,138.39 71.63,138.47 71.51,138.59 71.27,138.59 71.15,138.47 71.15,138.39 71.03,138.27 70.78,138.27 70.66,138.39 70.66,138.47 70.54,138.59 70.3,138.59 70.18,138.47 70.18,138.39 70.06,138.27 69.82,138.27 69.7,138.39 69.7,138.47 69.58,138.59 69.34,138.59 69.22,138.47 69.22,138.39 69.1,138.27 68.85,138.27 68.73,138.39 68.73,138.47 68.61,138.59 68.37,138.59 68.25,138.47 68.25,138.39 68.13,138.27 67.89,138.27 67.77,138.39 67.77,138.47 67.65,138.59 67.41,138.59 67.29,138.47 67.29,138.39 67.17,138.27 66.92,138.27 66.8,138.39 66.8,138.47 66.68,138.59 66.44,138.59 66.32,138.47 66.32,138.39 66.2,138.27 65.96,138.27 65.84,138.39 65.84,138.47 65.72,138.59 64.36,138.59 64.24,138.47 64.24,138.02 64.36,137.9 64.87,137.9 65,137.77 65,136.68 65.04,136.64 v1(65.04,135.67)
  BOTTOM w0.121: v1(65.04,135.67) 63.44,134.08 63.44,133.8 63.56,133.68 65,133.68 65.12,133.56 65.12,133.32 65,133.2 62.84,133.2 62.71,133.07 62.71,132.84 62.84,132.71 65,132.71 65.12,132.59 65.12,132.35 65,132.23 62.58,132.23 62.46,132.11 62.46,131.88 62.58,131.75 65,131.75 65.12,131.63 65.12,131.39 65,131.27 62.52,131.27 62.39,131.14 62.39,130.91 62.52,130.78 65,130.78 65.12,130.66 65.12,130.42 65,130.3 62.65,130.3 62.52,130.17 62.52,129.95 62.65,129.82 65,129.82 65.12,129.7 65.12,129.46 65,129.34 63.56,129.34 63.44,129.22 63.44,125.19 62.78,124.53 62.78,122.71 69.06,116.43 69.06,111.12 69.19,110.99 69.19,106.27 69.88,105.58 69.88,104.27 69.88,104.27 69.88,104.05 69.51,103.67 69.51,100.58 69.69,100.4 69.69,99.55 69.88,99.35 69.88,95.47 v1(70.29,95.06)
EXP_SPI0_CS1: length 59.4
  TOP w0.121: J5.17 75.16,138.02 67.61,138.02 67.14,137.55 67.14,136.56 v1(66.51,135.93) ; 71.28,93.26 71.67,93.26 v1(72.05,92.87)
  BOTTOM w0.121: v1(66.51,135.93) 65.37,134.78 65.37,133.29 65.63,133.02 65.63,123.28 65.82,123.09 65.82,120.59 65.83,120.58 65.83,120.56 69.42,116.97 69.42,111.24 69.44,111.21 69.44,106.38 70.13,105.68 70.13,103.95 69.77,103.58 69.77,100.67 69.93,100.5 69.93,99.9 70.13,99.71 70.13,95.79 70.38,95.54 71.17,95.54 71.47,95.24 71.47,93.45 v1(72.05,92.87)
EXP_SPI0_D0: length 4.5
  TOP w0.121: R205.2 79.16,134.78 v1(79.18,134.78)
  BOTTOM w0.121: v1(79.18,134.78) 79.18,135.04 79.06,135.17 78.65,135.17 78.52,135.29 78.52,135.55 78.65,135.67 79.06,135.67 79.18,135.8 79.18,136.94 79.06,137.07 J5.15
EXP_UART0_CTSN: length 39.7
  TOP w0.121: R213.2 79.79,105.29 v1(79.95,105.45) ; J5.21 71.98,136.12 77.43,136.12 v1(77.47,136.16)
  BOTTOM w0.121: v1(77.47,136.16) 77.14,135.84 77.14,133.75 78.33,132.56 78.33,122.02 78.88,121.46 78.88,107.72 79.51,107.09 79.51,106.62 79.51,105.91 79.57,105.85 79.57,105.83 v1(79.95,105.45)
EXP_UART0_RTSN: length 47.8
  TOP w0.121: v1(80.43,100.43) 80.44,100.43 80.68,100.19 R216.2 ; v1(77.59,135.22) 76.56,135.22 76.05,135.72 69.84,135.72 J5.23
  BOTTOM w0.121: v1(77.59,135.22) 77.48,135.11 77.48,133.84 78.58,132.75 78.58,122.39 79.13,121.83 79.13,107.82 79.76,107.2 79.76,106.72 79.76,106.27 80.39,105.64 80.39,105.55 80.4,105.54 80.4,105.13 80.27,105.01 79.77,105.01 79.67,104.9 79.67,104.18 79.79,104.05 80.17,104.05 80.4,103.83 80.4,100.47 v1(80.43,100.43)
EXP_UART0_RXD: length 51.1
  TOP w0.121: v1(80.65,98.75) 80.65,98.62 R220.2 ; J5.25 65.95,135.72 66.2,135.47 71.15,135.47 71.41,135.22 v1(75.93,135.22)
  BOTTOM w0.121: v1(75.93,135.22) 75.93,133.77 76.36,133.34 76.36,130.07 76.18,129.89 76.18,129.61 76.05,129.49 76.05,124.25 76.68,123.62 76.68,122.34 78.64,120.38 78.64,107.62 79.26,106.99 79.26,106.52 79.26,106.52 79.26,105.81 79.33,105.75 79.33,105.17 79.33,103.75 79.99,103.09 79.99,99.41 v1(80.65,98.75)
EXP_UART0_TXD: length 43.8
  TOP w0.121: R222.2 72.38,98.34 v1(71.93,98.79) ; J5.27 63.41,135.29 64.61,134.1 v1(65.88,134.1)
  BOTTOM w0.121: v1(71.93,98.79) 71.93,98.85 71.99,98.91 71.99,100.4 70.59,101.8 70.59,103.7 70.63,103.74 70.63,105.89 69.93,106.58 69.93,111.11 70.32,111.5 70.32,116.42 66.08,120.66 66.08,123.19 65.88,123.39 v1(65.88,134.1)
EXP_UART1_CTSN: length 42.9
  TOP w0.121: R225.2 v1(74.21,104.94) ; J5.29 60.87,135.85 63.07,133.65 66.47,133.65 66.66,133.84 67.85,133.84 v1(67.86,133.85)
  BOTTOM w0.121: v1(74.21,104.94) 74.21,119.87 74.06,120.02 74.06,120.11 72.09,122.08 69.68,122.08 69.38,122.39 69.38,123.54 68.48,124.44 68.48,133.22 v1(67.86,133.85)
EXP_UART1_RTSN: length 50
  TOP w0.121: J5.31 58.33,136.08 58.94,135.47 60.39,135.47 62.45,133.41 68.2,133.41 v1(68.64,133.84) ; R229.2 v1(75.22,101.26)
  BOTTOM w0.121: v1(75.22,101.26) 74.9,101.58 74.9,105.01 74.45,105.45 74.45,119.97 74.3,120.12 74.3,120.22 72.18,122.34 70.14,122.34 70.14,122.34 69.93,122.34 69.63,122.65 69.63,123.65 68.73,124.54 68.73,133.39 68.64,133.48 v1(68.64,133.84)
EXP_UART1_RXD: length 50.1
  TOP w0.121: R232.2 v1(73.7,100.49) ; J5.33 57.75,135.11 60.33,135.11 62.48,132.96 v1(67.88,132.96)
  BOTTOM w0.121: v1(67.88,132.96) 68.24,132.61 68.24,124.36 67.92,124.04 67.92,123.68 68.24,123.36 68.24,120.25 71.37,117.12 71.37,103.44 71.36,103.42 71.36,102.1 72.97,100.49 v1(73.7,100.49)
EXP_UART1_TXD: length 56.9
  TOP w0.121: J5.35 54.24,137.07 55.56,135.75 56.53,135.75 57.42,134.86 60.23,134.86 62.57,132.52 69.79,132.52 v1(69.89,132.63) ; R236.2 75.48,97.7 75.48,98.66 v1(75.09,99.04)
  BOTTOM w0.121: v1(69.89,132.63) 70.71,131.8 70.71,124.37 70.71,124.16 74.55,120.32 74.55,120.22 74.56,120.21 74.7,120.07 74.7,105.59 75.22,105.07 75.22,101.88 75.73,101.37 75.73,99.54 75.22,99.04 v1(75.09,99.04)
EXP_WAKEUP: length 1.8
  BOTTOM w0.121: R207.1 J5.18
EXP_XDMA_EVENT_INTR0: length 49.4
  TOP w0.121: R221.1 65.76,96.05 v1(65.51,95.8)
  BOTTOM w0.121: J5.28 62.06,138.26 62.06,136.05 60.7,134.69 60.7,122.92 65.64,117.98 65.64,105.2 66.4,104.43 66.4,102.55 66,102.15 66,100.17 65.32,99.48 65.32,99.2 65.82,98.7 65.82,97.51 65.51,97.19 v1(65.51,95.8)
EXP_XDMA_EVENT_INTR1: length 53.7
  TOP w0.121: v1(65.19,92.24) 65.44,91.99 R228.1
  BOTTOM w0.121: J5.32 59.35,138.59 59.35,135.04 58.3,134 58.3,130.36 58.64,130.03 58.64,124.24 61.45,121.43 61.45,118.02 65.39,114.09 65.39,105.09 66.15,104.33 66.15,102.65 65.76,102.26 65.76,100.44 65.05,99.73 65.05,99.12 65.19,98.98 65.19,98.08 64.37,97.26 64.37,95.23 65.57,94.03 65.57,92.62 v1(65.19,92.24)
F_ADBUS0: length 5.6
  TOP w0.121: R576.2 9.18,69.5 9.32,69.64 U58.16
F_ADBUS1: length 4
  TOP w0.121: U58.17 11.27,70.07 R577.2
F_ADBUS2: length 3.8
  TOP w0.121: U58.18 11.77,69.56 R578.2
F_ADBUS3: length 3.6
  TOP w0.121: U58.19 12.27,69.55 12.23,69.5 R579.2
F_ADBUS4: length 3.6
  TOP w0.121: U58.21 13.27,71.52 13.31,71.49 13.31,69.56 13.25,69.5 R580.2
F_ADBUS5: length 3.7
  TOP w0.121: U58.26 15.77,70.51 15.53,70.27 R581.2
F_ADBUS6: length 3.6
  TOP w0.121: U58.23 14.27,69.51 14.26,69.5 R582.2
F_ADBUS7: length 3.7
  TOP w0.121: R583.2 17.56,69.5 17.77,69.71 U58.30
FT_SRESET: length 24.8
  TOP w0.121: v1(5.63,51.22) R626.2 6.51,51.72 6.75,51.96 U55.1 ; R581.1 v1(15.53,67.12)
  BOTTOM w0.121: v1(5.63,51.22) 7.15,52.74 7.15,54.14 9.31,56.3 11.6,56.3 15.53,60.24 v1(15.53,67.12)
FT_SRESETB: length 2.7
  TOP w0.121: U60.6 11.85,52.75 12.6,52 13.02,52 R575.2
FT_SRESETN: length 6.7
  TOP w0.121: v1(11.41,55.54) 11.1,55.23 U60.1 ; U55.4 v1(8.05,56.3)
  LY3 w0.133: v1(8.05,56.3) 10.65,56.3 v1(11.41,55.54)
FT_VBUS: length 35.2
  TOP w0.121: U55.2 7.4,56.63 v1(8.04,57.26)
  BOTTOM w0.121: v1(8.04,57.26) 9.18,57.26 9.89,56.55 11.46,56.55 13.05,58.15 13.05,58.15 15.02,60.12 15.02,67.5 15.92,68.4 15.92,76.84 14.01,78.76 v1(14.01,80) R590.1
FTDI_REF: length 4
  TOP w0.121: v1(12.1,78.68) 11.29,79.49 11.26,79.49 11.23,79.52 U58.6
  BOTTOM w0.121: R584.1 v1(12.1,78.68)
FTDI_VPHY: length 6.2
  TOP w0.254: U58.4 7.12,80.52 7.09,80.56 C323.2
  TOP w0.635: C323.2 6.13,80.94 C320.2 4.87,80.89 FB23.1
FTDI_VPLL: length 6.3
  TOP w0.254: C329.2 7.09,77.63 7.47,78.02 7.83,78.02 7.84,78.03 8.26,78.03 8.27,78.02 U58.9
  TOP w0.635: C326.2 4.87,76.41 FB24.1 6.26,77.89 C329.2
GPMC_A0: length 53.7
  TOP w0.121: v1(113.02,128.18) 112.51,128.69 109.79,128.69 109.51,128.96 103.16,128.96 102.89,128.69 93.46,128.69 92.32,127.55 88.15,127.55 87.54,128.15 J6.2 ; R193.1 v1(114.34,153.83)
  BOTTOM w0.121: v1(114.34,153.83) 114.34,148.35 113.06,147.07 113.06,138.64 113.01,138.59 113.01,134.86 113.06,134.8 113.06,129.86 113.02,129.81 v1(113.02,128.18)
GPMC_A1: length 11.8
  TOP w0.121: J6.4 85.74,128.18 86.63,129.07 88.07,129.07 88.96,128.18 89.57,128.18 89.7,128.31 89.7,128.79 89.57,128.92 89.1,128.92 88.98,129.04 88.98,129.63 89.1,129.75 90.26,129.75 90.38,129.63 90.38,127.92 90.51,127.79 91.1,127.79 91.22,127.92 R196.1
GPMC_A2: length 11.7
  TOP w0.121: J6.6 82.46,129.2 83.1,129.83 83.35,129.83 83.68,129.5 84.19,129.5 84.52,129.83 84.87,129.83 85.39,129.32 86.14,129.32 86.34,129.52 88.34,129.52 89.13,130.31 90.59,130.31 91.22,129.68 R198.1
GPMC_A3: length 11.8
  TOP w0.121: R202.1 90.33,127.04 90.08,127.29 80.81,127.29 J6.8
GPMC_A4: length 51.2
  TOP w0.121: R206.1 101.25,152.94 88.33,152.94 87.82,152.43 86,152.43 85.93,152.36 84.07,152.36 84,152.43 77.22,152.43 77.06,152.27 v1(77.06,152.26)
  BOTTOM w0.121: J6.10 77.38,133.03 76.9,133.51 76.9,136.54 77.06,136.7 v1(77.06,152.26)
GPMC_A5: length 51.8
  TOP w0.121: v1(74.39,152.01) 75.11,152.72 84.06,152.72 84.18,152.61 85.82,152.61 86.06,152.84 87.88,152.84 88.22,153.19 98.83,153.19 R209.1
  BOTTOM w0.121: J6.12 74.87,128.18 75.23,128.55 75.23,135.69 74.91,136.01 74.91,140.53 74.26,141.18 74.26,148.12 74.59,148.45 74.59,150.79 74.39,150.98 v1(74.39,152.01)
GPMC_A6: length 54
  TOP w0.121: v1(69.23,152.16) 70.04,152.97 84.16,152.97 84.28,152.85 85.72,152.85 85.96,153.09 87.78,153.09 88.12,153.43 96.16,153.43 R214.1
  BOTTOM w0.121: v1(69.23,152.16) 69.23,147.8 69.67,147.36 69.67,141.01 69.51,140.85 69.51,136.31 69.13,135.93 69.13,128.81 J6.16
GPMC_A7: length 51.7
  TOP w0.121: v1(68.77,152.79) 69.13,152.79 69.55,153.21 84.27,153.21 84.38,153.1 85.62,153.1 85.86,153.34 87.68,153.34 88.02,153.68 93.23,153.68 R217.1
  BOTTOM w0.121: v1(68.77,152.79) 68.77,146.67 67.75,145.66 67.75,141.03 67.54,140.82 67.54,134.66 67.22,134.34 J6.18
GPMC_A8: length 50.2
  TOP w0.121: v1(67.89,152.94) 67.89,152.92 68.43,153.46 84.37,153.46 84.48,153.35 85.52,153.35 85.75,153.59 87.57,153.59 87.92,153.93 89.29,153.93 R223.1
  BOTTOM w0.121: J6.22 62.14,133.74 64.92,136.52 64.92,144.3 67.73,147.1 67.73,151.97 67.86,152.1 67.86,152.29 67.89,152.31 v1(67.89,152.94)
GPMC_A9: length 2
  BOTTOM w0.121: R226.1 J6.24
GPMC_A10: length 130.9
  TOP w0.121: v1(118.08,166.09) 125.77,158.41 125.77,150.79 127.93,148.63 131.07,148.63 131.7,148 137.11,148 137.31,148.2 v1(139,148.2) ; R230.1 v1(139.48,154.09)
  BOTTOM w0.121: v1(118.08,166.09) 115.9,166.09 115.86,166.13 72.86,166.13 67.45,160.71 67.45,151.39 61.51,145.46 61.51,143.14 59.37,141 57.59,141 57.06,140.47 J6.26 ; v1(139,148.2) 139,149.73 139.48,150.21 139.48,152.25 139.04,152.69 139.04,153.64 139.48,154.08 v1(139.48,154.09)
GPMC_A11: length 1.8
  BOTTOM w0.121: R233.1 J6.28
HDMI_AUDBCLK: length 199
  TOP w0.121: v1(132.02,36.49) 132.02,36.21 134.28,33.95 135.17,33.95 135.42,33.69 U10.45 ; R316.1 53.76,132.12 54.4,131.48 54.4,130.28 55.59,129.09 60.57,129.09 60.92,129.44 65.54,129.44 65.91,129.08 66.77,129.08 76.27,129.08 76.33,129.02 76.9,129.02 76.97,129.08 81.83,129.08 82.96,130.21 87.92,130.21 89.95,132.24 90.67,132.24 91.74,133.32 92.17,133.32 92.22,133.27 97.32,133.27 97.52,133.07 97.88,133.07 98.14,133.33 98.14,133.7 98.13,133.71 98.19,133.78 103.18,133.78 103.81,133.15 117.25,133.15 118.78,131.61 128.66,131.61 130.8,129.48 133.33,129.48 134.59,128.22 134.59,127.97 135.72,126.84 140.59,126.84 141.51,125.92 142.3,125.92 v1(142.48,126.1)
  BOTTOM w0.121: v1(142.48,126.1) 141.76,125.38 141.76,117.18 142.65,116.29 142.65,114.98 142.55,114.88 142.55,95.67 143.28,94.94 143.28,89.02 144.62,87.68 144.62,83.3 144.06,82.73 144.06,76.46 143.47,75.88 143.47,59.63 133.86,50.02 133.86,47.36 132.06,45.55 132.06,36.53 v1(132.02,36.49)
HDMI_AUDD0: length 272.7
  TOP w0.121: v1(37.22,129.58) 37.22,128.94 38.82,127.34 43.09,127.34 44.16,126.28 R318.1 ; v1(24.04,62.9) 21.44,62.9 17.12,58.58 17.12,44.17 18.58,42.71 53.49,42.71 54.63,43.85 58.79,43.85 59.36,43.28 v1(60.04,43.28) ; U10.41 134.31,35.69 132.88,37.12 127.67,37.12 125.64,35.09 125.64,34.07 124.81,33.25 123.29,33.25 122.56,32.52 v1(120.34,32.52)
  BOTTOM w0.121: v1(120.34,32.52) 120.34,20.52 118.27,18.45 108.62,18.45 108.05,17.88 96.28,17.88 94.57,16.17 92.56,16.17 91.87,16.86 85.13,16.86 84.87,17.12 63.54,17.12 60.04,20.61 v1(60.04,43.28) ; v1(37.22,129.58) 37.22,129.49 34.96,127.23 34.96,113.89 32.67,111.6 32.67,107.22 33.31,106.58 33.31,99.67 32.79,99.14 32.79,98.06 32.66,97.93 32.66,97.89 32.64,97.88 32.64,91.7 32.57,91.63 32.57,87.26 32.57,87.25 32.57,87.06 27.15,81.64 27.15,67.41 24.29,64.55 24.29,63.16 v1(24.04,62.9)
HDMI_AUDD1: length 172.2
  TOP w0.121: R319.1 48.02,113.58 48.7,114.25 48.7,114.89 49.47,115.65 57.11,115.65 v1(57.57,115.2) ; v1(55.05,49.25) 55.49,49.25 55.69,49.44 62.96,49.44 62.97,49.44 66.23,49.44 66.63,49.84 72.29,49.84 74.28,47.85 83.11,47.85 83.3,47.66 95.3,47.66 97.46,45.5 113.02,45.5 113.52,46.01 128.82,46.01 v1(130.97,43.85) ; v1(130.85,39.28) 131.23,39.28 134.32,36.19 U10.40
  BOTTOM w0.121: v1(130.85,39.28) 130.85,41.44 130.97,41.57 v1(130.97,43.85) ; v1(57.57,115.2) 58.09,114.67 58.09,113.77 58.08,113.75 58.08,110.27 57.19,109.38 57.19,94.91 56.81,94.53 56.81,92.11 57.19,91.73 57.19,88.62 57.48,88.33 58.6,87.21 58.6,86.53 58.6,86.12 59.34,85.38 59.34,82.56 59.98,81.92 59.98,81.5 59.96,81.48 59.96,79.88 59.98,79.86 59.98,73.19 56.67,69.88 56.67,68.37 56.67,58.96 55.16,57.44 55.16,49.8 55.05,49.69 v1(55.05,49.25)
HDMI_AUDD2: length 183.7
  TOP w0.121: v1(59.63,107.23) 61.05,108.65 66,108.65 66.3,108.95 78.67,108.95 80.26,107.35 80.26,106.69 81.43,105.52 81.43,104.42 83.12,102.73 83.12,102.02 R320.1 ; U10.39 134.33,36.69 127.86,43.15 v1(127.35,43.15) ; v1(55.6,56.68) 58.33,56.68 59.92,55.09 64.36,55.09 65.05,54.4 73.05,54.4 73.95,53.5 75.22,53.5 77.17,51.55 86.89,51.55 86.98,51.46 87.39,51.46 104.03,51.46 104.4,51.09 109.72,51.09 111.06,52.43 116.79,52.43 116.93,52.58 120.53,56.17 v1(127.23,56.17)
  BOTTOM w0.121: v1(55.6,56.68) 55.6,57.47 56.92,58.79 56.92,68.47 56.92,69.75 60.23,73.06 60.23,79.97 60.21,79.99 60.21,81.38 60.23,81.4 60.23,82.03 59.59,82.66 59.59,85.48 58.85,86.22 58.85,87.31 58.17,88 57.73,88.43 57.73,92.79 57.82,92.88 57.82,99.5 57.82,102.57 58.51,103.26 58.51,106.11 v1(59.63,107.23) ; v1(127.23,56.17) 127.23,43.28 v1(127.35,43.15)
HDMI_AUDD3: length 150.9
  TOP w0.121: v1(143.17,125.28) 143.13,125.32 142.59,125.32 142.34,125.58 141.5,125.58 140.49,126.59 135.61,126.59 134.34,127.86 134.34,128.12 133.45,129.01 130.85,129.01 129.89,129.96 126.85,129.96 126.44,130.37 100.81,130.37 99.89,129.45 96.24,129.45 96.05,129.64 v1(94.53,129.64) ; U10.37 134.89,37.69 v1(134.7,37.88)
  BOTTOM w0.121: v1(134.7,37.88) 132.8,39.78 132.8,45.59 134.36,47.15 134.47,47.26 134.47,49.71 143.97,59.21 143.97,75.67 144.55,76.26 144.55,82.53 145.12,83.1 145.12,87.88 143.93,89.07 143.93,94.99 143.09,95.83 143.09,102.39 143.38,102.68 143.38,113.94 143.55,114.11 143.55,116.45 142.82,117.17 142.82,122.01 143.07,122.26 143.07,122.88 143.17,122.98 v1(143.17,125.28) ; v1(94.53,129.64) 94.53,132.24 R321.1
HDMI_AUDFSX: length 174.6
  TOP w0.121: v1(82.25,106.59) R317.1 ; v1(134.05,35.09) 134.94,34.19 135.27,34.19 135.27,34.19 U10.44 ; v1(83.1,119.67) 83.6,119.67 84.74,120.8 90.4,120.8 90.94,121.35 100.01,121.35 102.26,123.6 103.32,123.6 103.32,123.59 112.15,123.59 112.6,123.15 123.25,123.15 123.58,123.47 132.29,123.47 132.29,123.47 140.74,123.47 140.82,123.54 v1(142.4,123.54)
  BOTTOM w0.121: v1(142.4,123.54) 142.01,123.15 142.01,117.28 142.98,116.31 142.98,115.04 142.9,114.96 142.9,114.88 142.81,114.79 142.81,95.76 143.65,94.92 143.65,89 144.87,87.78 144.87,83.2 144.3,82.63 144.3,76.36 143.72,75.78 143.72,59.31 134.11,49.7 134.11,47.25 132.3,45.45 132.3,37.31 132.75,36.87 132.75,36.38 v1(134.05,35.09) ; v1(83.1,119.67) 82.84,119.67 81.52,118.35 81.52,107.33 v1(82.25,106.59)
HDMI_AUDMCLK: length 137.1
  TOP w0.121: v1(127.67,45.31) 127.67,43.73 134.21,37.19 U10.38 ; v1(61.38,91.1) 63.92,91.1 R315.1 ; v1(127.48,56.81) 125.51,56.81 125.14,56.43 120.44,56.43 116.69,52.68 110.91,52.68 109.57,51.35 104.5,51.35 104.13,51.71 96.3,51.71 87.09,51.71 86.99,51.8 77.31,51.8 75.36,53.75 74.05,53.75 73.15,54.65 65.18,54.65 63.79,56.04 60.74,56.04 v1(59.35,57.44)
  BOTTOM w0.121: v1(127.48,56.81) 127.48,56.54 127.67,56.35 127.67,55.56 127.67,55.56 127.67,48.04 127.48,47.85 127.48,46.59 127.67,46.4 v1(127.67,45.31) ; v1(61.38,91.1) 61.38,89.48 62.09,88.77 62.09,87.74 62.81,87.02 62.81,83.99 63.47,83.33 63.47,81.91 63.86,81.52 63.86,72.36 63.42,71.93 60.68,69.18 60.68,61.35 60.8,61.23 60.8,60 60.68,59.88 60.68,58.77 v1(59.35,57.44)
HDMI_AVCC12: length 26.2
  TOP w0.305: U10.60 v1(139.13,29.35) ; U10.66 v1(142.13,29.35)
  BOTTOM w0.762: v1(139.13,29.35) 139.13,29.09 139.86,28.36 141.64,28.36 ; 141.64,28.36 142.13,28.85 v1(142.13,29.35) 141.77,29.72 141.77,30.14 ; 141.64,28.36 141.52,28.23 141.52,26.71 145.26,22.96 155.04,22.96 v1(156.25,21.75) ; C153.1 v1(158.53,20.1)
HDMI_CEC: length 48.8
  TOP w0.121: U11.1 137.54,19.05 v1(137.96,19.47) ; R277.1 v1(161.96,22.26) 160.57,23.66 148.63,23.66 144.63,27.66 U10.71
  BOTTOM w0.121: v1(137.96,19.47) 142.53,19.47 144.56,21.5 149.52,21.5 150.66,20.36 157.46,20.36 159.8,22.7 161.52,22.7 v1(161.96,22.26)
HDMI_CEC_D: length 260
  TOP w0.121: v1(58.13,56.24) 58.14,56.24 59.54,54.84 64.24,54.84 64.92,54.15 72.95,54.15 73.85,53.26 75.06,53.26 77.01,51.31 86.78,51.31 86.88,51.21 87.5,51.21 96.1,51.21 96.51,51.21 103.93,51.21 104.37,50.77 109.99,50.77 111.39,52.17 116.88,52.17 116.89,52.18 119.23,54.52 v1(126.66,54.52) ; U10.50 134.58,31.19 133.77,32 130.15,32 130.02,31.86 v1(129.58,31.86) ; R296.1 103.41,155.1 103.41,152.31 103.04,151.93 98.4,151.93 97.64,152.69 88.43,152.69 87.9,152.16 87.81,152.16 87.75,152.11 83.97,152.11 83.9,152.18 78.02,152.18 77.63,151.8 76.49,151.8 75.86,152.44 75.22,152.44 74.84,152.06 74.84,151.8 74.59,151.55 73.15,151.55 72.71,151.98 70.07,151.98 69.63,151.55 68.62,151.55 67.22,152.95 67.22,153.58 v1(66.71,154.09)
  BOTTOM w0.121: v1(129.58,31.86) 128.05,33.39 128.05,40.36 126.91,41.51 126.91,53.13 126.66,53.38 v1(126.66,54.52) ; v1(58.13,56.24) 58.13,56.98 59.66,58.52 59.66,69.22 63.11,72.67 63.11,81.21 62.73,81.6 62.73,83.03 62.07,83.69 62.07,86.6 61.35,87.32 61.35,88.05 61.35,88.32 60.21,89.46 60.21,91.77 60.3,91.86 60.3,92.68 61.12,93.51 61.12,97.7 61.95,98.53 61.99,98.53 62.25,98.79 62.25,100.72 63.38,101.85 63.38,106.02 62.39,107 62.39,113.37 59.22,116.55 59.22,120.43 55.79,123.86 55.79,132.84 55.79,132.85 55.79,134.91 54.65,136.05 54.65,140.5 55.79,141.64 59.66,141.64 61.26,143.24 61.26,145.56 62.9,147.2 62.9,147.48 66.77,151.35 66.77,154.03 v1(66.71,154.09)
HDMI_CLK+: length 27.6
  TOP w0.095: U10.59 138.63,27.87 138.52,27.76 138.52,26.96 138.47,26.91 138.47,23.94 137.6,23.07 137.6,21.36 139.1,19.86 139.1,15.51 141.39,13.21 142.37,13.21 142.55,13.4 U11.16 144.56,13.4 144.69,13.27 145.92,13.27 147.3,11.9 147.3,9.71 147.39,9.61 147.56,9.61 147.66,9.52 J10.10
HDMI_CLK-: length 27.6
  TOP w0.095: J10.12 146.66,9.52 146.75,9.61 146.92,9.61 147.02,9.71 147.02,11.78 145.81,12.99 144.82,12.99 144.57,12.75 U11.15 142.55,12.75 142.37,12.93 141.28,12.93 138.82,15.39 138.82,19.75 137.32,21.25 137.32,23.19 138.19,24.05 138.19,27.02 138.24,27.08 138.24,27.76 138.13,27.87 U10.58
HDMI_CT_HPD: length 195.5
  TOP w0.121: U11.12 137.58,11.41 v1(137.58,10.83) ; v1(155.29,142.09) 147.6,142.09 146.95,142.73 141.18,142.73 140.14,143.78 131.51,143.78 128.47,146.82 126.56,146.82 117.77,155.61 R323.1
  LY3 w0.133: v1(137.58,10.83) 141.29,14.54 149.82,14.54 152.5,17.22 152.5,17.49 152.76,17.76 153.04,17.76 156.91,21.63 156.91,35.17 158.38,36.64 v1(158.38,40.78)
  BOTTOM w0.121: R322.2 137.45,10.96 v1(137.58,10.83) ; v1(155.29,142.09) 155.29,125.22 156.58,123.94 156.58,98.23 158.38,96.43 158.38,57.71 158.59,57.5 158.59,57.13 158.38,56.92 158.38,55.79 159.24,54.93 159.24,41.64 v1(158.38,40.78)
HDMI_CVCC12: length 15.5
  TOP w0.305: U10.5 146.69,31.19 v1(147.1,30.77) ; U10.42 135.39,35.19 v1(135.04,34.84) ; v1(141.64,39.28) 141.64,38.4 U10.26 ; v1(135.04,32.65) 135.08,32.69 U10.47 ; v1(134.96,29.73) 135.06,29.73 135.11,29.69 U10.53 ; U10.12 v1(147.08,34.69)
  TOP w0.762: v1(150.41,21.37) 150.91,20.87 v1(151.29,20.87) 151.74,20.42 FB11.1
  BOTTOM w0.762: v1(147.08,34.69) 146.23,34.69 C142.1 ; C146.1 135.19,32.55 135.09,32.65 v1(135.04,32.65) ; C147.1 135.29,30.26 134.96,29.93 v1(134.96,29.73) ; C143.1 146.37,31.28 146.87,30.77 v1(147.1,30.77) ; v1(135.04,34.84) 135.17,34.96 C145.1 ; C144.1 v1(141.64,39.28)
HDMI_D0: length 109.4
  TOP w0.121: U10.32 138.63,40.94 138.5,41.06 136.69,41.06 136.56,41.19 136.56,42.18 136.44,42.3 135.93,42.3 135.8,42.43 v1(135.8,43.5) ; R278.1 108.14,92.62 109.21,93.69 114.97,93.69 115.38,93.28 117.23,93.28 v1(117.69,93.74)
  LY3 w0.133: v1(135.8,43.5) 135,44.3 127.28,44.3 126.35,43.37 122.85,43.37 122.41,42.94 v1(118.71,42.94)
  LY4 w0.133: v1(117.69,93.74) 117.19,93.24 117.19,91.6 117.32,91.48 118.02,91.48 118.15,91.35 118.15,90.05 118.02,89.93 117.32,89.93 117.19,89.8 117.19,87.33 117.51,87.01 117.51,85.66 117.19,85.34 117.19,84.54 117.32,84.41 118.37,84.41 118.5,84.28 118.5,84.01 118.37,83.88 117.32,83.88 117.19,83.74 117.19,83.48 117.32,83.34 118.37,83.34 118.5,83.21 118.5,82.94 118.37,82.81 117.32,82.81 117.19,82.68 117.19,82.41 117.32,82.28 118.37,82.28 118.5,82.14 118.5,81.88 118.37,81.74 117.32,81.74 117.19,81.61 117.19,81.34 117.32,81.21 118.37,81.21 118.5,81.08 118.5,80.81 118.37,80.68 117.32,80.68 117.19,80.54 117.19,80.28 117.32,80.14 118.37,80.14 118.5,80.01 118.5,79.74 118.37,79.61 117.32,79.61 117.19,79.48 117.19,79.21 117.32,79.08 118.37,79.08 118.5,78.94 118.5,78.68 118.37,78.54 117.32,78.54 117.19,78.41 117.19,75.75 118.59,74.35 118.59,65.33 119.49,64.43 119.49,63.64 118.83,62.98 118.83,59.22 118.3,58.69 118.3,56.68 118.43,56.55 118.83,56.55 118.96,56.68 118.96,57.72 119.09,57.85 119.52,57.85 119.65,57.72 119.65,43.07 119.51,42.94 v1(118.71,42.94)
HDMI_D1: length 91.6
  TOP w0.121: v1(136.94,43.47) 136.94,41.44 137.07,41.31 139,41.31 139.13,41.19 U10.31 ; R279.1 112.84,84.75 v1(113.23,85.14)
  LY3 w0.133: v1(146.04,87.03) 140.8,87.03 139.8,88.04 121.85,88.04 119.67,85.86 114.88,85.86 114.16,85.14 v1(113.23,85.14)
  BOTTOM w0.121: v1(146.04,87.03) 145.7,86.7 145.7,82.48 145.12,81.9 145.12,76.13 144.46,75.47 144.46,59.01 136.94,51.49 v1(136.94,43.47)
HDMI_D2: length 111.2
  TOP w0.121: v1(109.03,97.01) 104.89,97.01 103.42,95.54 100.62,95.54 100.37,95.29 ; U10.30 139.63,41.57 139.5,41.69 138.21,41.69 138.09,41.82 v1(138.09,43.47)
  LY3 w0.133: v1(109.03,97.01) 114.26,97.01 115,96.28 117.08,96.28 117.32,96.52 123.52,96.52 124.73,95.31 138.49,95.31 138.98,95.8 143.67,95.8 145.25,94.22 v1(145.25,93.46)
  BOTTOM w0.121: v1(145.25,93.46) 145.63,93.08 145.63,88.43 146.85,87.21 146.85,86.88 145.95,85.98 145.95,82.38 145.37,81.8 145.37,76.03 144.71,75.37 144.71,58.9 137.2,51.39 137.2,44.69 137.32,44.56 138.59,44.56 138.72,44.44 138.72,43.6 138.59,43.47 v1(138.09,43.47)
HDMI_D3: length 74
  TOP w0.121: U10.29 140.13,40.16 140.26,40.29 141.01,40.29 141.13,40.42 141.13,41.95 141.01,42.07 139.36,42.07 139.23,42.2 v1(139.23,43.47) ; v1(145.81,77.08) 149.9,77.08 150.02,76.95 150.02,76.06 149.9,75.93 144.84,75.93 144.72,76.06 144.72,77.08 144.59,77.2 144.06,77.2 143.93,77.08 143.93,76.06 143.8,75.93 143.06,75.93 141.9,77.1 R281.1
  BOTTOM w0.121: v1(145.81,77.08) 145.81,76.01 144.96,75.15 144.96,58.75 137.64,51.43 137.64,44.94 137.77,44.81 139.74,44.81 139.86,44.68 139.86,38.29 139.74,38.16 139.36,38.16 139.23,38.29 v1(139.23,43.47)
HDMI_D4: length 78
  TOP w0.121: U10.28 140.63,39.92 140.76,40.04 141.62,40.04 141.74,40.17 141.74,42.46 141.62,42.58 141.13,42.58 141.01,42.71 141.01,45.76 140.88,45.88 138.95,45.88 138.82,45.76 138.82,45.35 138.95,45.22 140.25,45.22 140.37,45.1 v1(140.37,43.47) ; R282.1 v1(146.26,80.56)
  BOTTOM w0.121: v1(140.37,43.47) 140.37,40.5 140.5,40.37 142.76,40.37 142.89,40.5 142.89,42.33 142.76,42.46 141.13,42.46 141.01,42.58 141.01,44.39 141.13,44.51 141.14,44.51 141.27,44.64 141.27,46.49 141.14,46.62 140.14,46.62 140.02,46.75 140.02,53.27 141.68,54.93 144.68,54.93 145.2,55.46 145.2,74.74 145.33,74.87 146.27,74.87 146.39,74.99 146.39,77.65 146.27,77.78 145.83,77.78 145.71,77.9 145.71,78.78 145.83,78.9 146.39,78.9 146.52,79.03 146.52,79.46 146.39,79.59 145.83,79.59 145.71,79.72 145.71,81.32 145.83,81.44 146.72,81.44 146.85,81.32 146.85,80.68 146.72,80.56 v1(146.26,80.56)
HDMI_D5: length 84.4
  TOP w0.121: U10.27 141.13,39.66 141.26,39.79 141.9,39.79 142.02,39.92 142.02,40.42 142.28,40.68 142.28,42.58 142.15,42.71 142.15,44.41 142.02,44.54 141.64,44.54 141.52,44.41 v1(141.52,43.47) ; R283.1 v1(125.89,81.83)
  LY3 w0.133: v1(125.89,81.83) 123.76,81.83 123.63,81.95 123.63,86.45 123.76,86.57 124.4,86.57 124.52,86.45 124.52,82.49 124.65,82.36 126.1,82.36 128.05,80.4 128.05,76.62 130.59,74.08 145.42,74.08 v1(145.65,74.31)
  BOTTOM w0.121: v1(141.52,43.47) 141.52,42.86 141.64,42.73 142.02,42.73 142.15,42.86 142.15,44.74 141.52,45.38 141.52,54.19 142.01,54.69 144.78,54.69 145.58,55.49 145.58,74.24 v1(145.65,74.31)
HDMI_D6: length 74.2
  TOP w0.121: v1(142.66,43.47) 142.58,43.39 142.58,41.5 142.71,41.38 143.48,41.38 143.6,41.25 143.6,40.83 143.48,40.7 142.71,40.7 142.58,40.58 142.58,40.14 142.27,39.83 142.27,39.81 142.13,39.67 U10.25 ; v1(146.82,78.46) 146.76,78.4 R284.1
  BOTTOM w0.121: v1(142.66,43.47) 142.66,46.54 142.53,46.67 142.4,46.67 142.27,46.8 142.27,47.08 142.4,47.2 142.92,47.2 143.05,47.33 143.05,47.67 142.92,47.79 142.4,47.79 142.27,47.92 142.27,48.15 142.4,48.28 142.84,48.28 142.97,48.4 142.97,48.63 142.84,48.76 142.4,48.76 142.27,48.88 142.27,49.24 142.4,49.36 145.55,49.36 145.68,49.49 145.68,52.13 145.81,52.26 146.24,52.26 146.37,52.13 146.37,48.98 146.24,48.86 145.6,48.86 145.48,48.73 145.48,48.32 145.6,48.2 146.24,48.2 146.37,48.07 146.37,47.12 146.49,47 146.93,47 147.06,47.12 147.06,52.98 147.08,53 147.08,53.35 146.9,53.53 142.58,53.53 142.45,53.66 142.45,54.06 142.58,54.19 146.06,54.19 146.19,54.32 146.19,72.15 146.81,72.77 146.81,78.44 v1(146.82,78.46)
HDMI_D7: length 89.5
  TOP w0.121: U10.24 142.63,39.51 143.85,40.73 143.85,41.5 143.72,41.62 142.96,41.62 142.83,41.75 142.83,42.73 142.89,42.79 144.38,42.79 144.5,42.91 144.5,45.71 144.38,45.83 144.03,45.83 143.9,45.71 143.9,44.56 143.78,44.44 143.32,44.44 143.19,44.56 143.19,45.71 143.06,45.83 142.68,45.83 142.56,45.71 142.56,44.04 142.68,43.91 143.67,43.91 143.8,43.78 v1(143.8,43.47) ; R285.1 126.14,83.86 125.89,84.1 v1(125.89,84.11) ; v1(143.29,48.1) 143.36,48.17 143.36,51.28 143.23,51.41 139.36,51.41 139.23,51.28 139.23,48.63 139.1,48.5 133.72,48.5 133.59,48.37 133.59,48.23 133.46,48.1 v1(132.12,48.1)
  BOTTOM w0.121: v1(125.89,84.11) 125.45,83.67 125.45,81.63 125.77,81.32 126.91,81.32 128.43,79.79 128.43,79.2 129.17,78.46 129.17,75.57 132.82,71.92 132.82,51.64 132.12,50.94 v1(132.12,48.1) ; v1(143.29,48.1) 143.29,47.63 143.42,47.51 144.02,47.51 144.15,47.38 144.15,46.8 144.02,46.67 143.34,46.67 143.22,46.54 143.22,46.32 143.34,46.19 143.93,46.19 144.06,46.06 144.06,45.78 143.93,45.66 143.42,45.66 143.29,45.53 143.29,45.17 143.42,45.05 143.93,45.05 144.06,44.92 144.06,44.64 143.93,44.51 143.42,44.51 143.29,44.39 143.29,41.87 143.42,41.74 143.9,41.74 144.03,41.87 144.03,42.57 143.8,42.8 v1(143.8,43.47)
HDMI_D8: length 117.5
  TOP w0.121: v1(144.94,43.47) 145.46,43.47 145.68,43.25 145.68,40.6 145.22,40.14 143.78,40.14 143.13,39.5 U10.23 ; v1(132.9,48.55) 133.01,48.65 133.02,48.65 136.02,51.66 143.52,51.66 143.8,51.38 v1(143.8,48.74) ; R286.1 105.07,93.84 105.24,94.02 105.83,94.02 106.01,94.19 116.19,94.19 v1(116.34,94.04)
  LY3 w0.133: v1(118.91,63.92) 121.58,61.25 125.01,61.25 126.91,59.35 127.1,59.35 127.26,59.51 127.45,59.51 127.64,59.33 127.64,59.14 127.47,58.97 127.47,58.78 128.63,57.63 128.63,56.65 128.76,56.52 132.19,56.52 132.32,56.39 132.32,56.12 132.19,55.99 128.76,55.99 128.63,55.85 128.63,55.59 128.76,55.45 132.19,55.45 132.32,55.32 132.32,55.05 132.19,54.92 128.76,54.92 128.63,54.79 128.63,54.52 128.76,54.39 132.19,54.39 132.32,54.25 132.32,53.99 132.19,53.85 128.76,53.85 128.63,53.72 128.63,52.89 131.49,50.03 131.49,49.97 v1(132.9,48.55)
  LY4 w0.133: v1(116.34,94.04) 116.34,85.89 116.57,85.66 116.57,73.29 118.33,71.53 118.33,64.5 v1(118.91,63.92)
  BOTTOM w0.121: v1(144.94,43.47) 144.94,43.83 144.77,44 144.46,44 144.33,44.13 144.33,46.64 144.39,46.7 144.39,47.48 144.24,47.63 144.24,48.3 v1(143.8,48.74)
HDMI_D9: length 94
  TOP w0.121: U10.20 144.63,39.05 144.86,39.28 145.6,39.28 146.33,40.01 146.33,42.58 v1(147.23,43.47) ; v1(121.65,85.05) 121.65,86.36 121.2,86.82 116.82,86.82 116.78,86.78 R287.1 ; v1(129.81,48.63) 130.97,48.63 131.89,49.54 133.56,49.54 135.93,51.91 141.33,51.91 141.34,51.9 144.28,51.9 144.5,51.68 144.5,48.48 v1(144.94,48.04)
  BOTTOM w0.121: v1(121.65,85.05) 121.65,82.33 122.67,81.32 122.67,80.24 122.55,80.12 121.44,80.12 121.32,80 121.32,79.76 121.44,79.64 122.55,79.64 122.67,79.52 122.67,79.28 122.55,79.16 121.44,79.16 121.32,79.04 121.32,78.8 121.44,78.68 122.55,78.68 122.67,78.55 122.67,78.31 122.55,78.19 121.44,78.19 121.32,78.07 121.32,77.83 121.44,77.71 122.55,77.71 122.67,77.59 122.67,77.35 122.55,77.23 121.44,77.23 121.32,77.11 121.32,76.87 121.44,76.74 122.55,76.74 122.67,76.62 122.67,76.38 122.55,76.26 121.44,76.26 121.32,76.14 121.32,75.9 121.44,75.78 122.55,75.78 122.67,75.66 122.67,70.78 127.21,66.23 127.21,61.96 129.81,59.37 v1(129.81,48.63) ; v1(147.23,43.47) 147.23,45.68 144.94,47.97 v1(144.94,48.04)
HDMI_D10: length 68.9
  TOP w0.121: v1(148.25,82.97) 150.71,82.97 150.84,83.1 150.84,83.55 150.71,83.68 147.66,83.68 147.53,83.55 147.53,82.83 147.41,82.71 146.98,82.71 146.85,82.83 146.85,83.55 146.72,83.68 146.29,83.68 146.16,83.55 146.16,82.83 146.04,82.71 145.66,82.71 145.53,82.83 145.53,83.55 145.4,83.68 145.05,83.68 144.92,83.55 144.92,83.1 144.79,82.97 142.33,82.97 142.21,82.85 142.16,82.85 R288.1 ; v1(148.25,43.47) 148.25,40.55 146.08,38.39 U10.19
  BOTTOM w0.121: v1(148.25,43.47) 148.25,45.63 148.67,46.05 148.67,51.7 148,52.36 148,71.75 147.51,72.23 147.51,78.17 147.64,78.29 147.97,78.29 148.09,78.42 148.09,79.51 148.22,79.64 148.5,79.64 148.63,79.77 148.63,80.17 148.5,80.3 148.22,80.3 148.09,80.43 148.09,80.89 148.22,81.01 148.82,81.01 148.95,81.14 148.95,81.57 148.82,81.7 148.22,81.7 148.09,81.83 148.09,82.12 148.22,82.25 148.82,82.25 148.95,82.38 148.95,83.78 148.82,83.91 148.37,83.91 148.25,83.78 v1(148.25,82.97)
HDMI_D11: length 68.7
  TOP w0.121: R289.1 v1(125.77,77.76) ; v1(150.28,40.04) 149.39,40.04 149.26,39.92 149.26,38.29 148.66,37.69 U10.18
  LY3 w0.133: v1(125.77,77.76) 126.21,77.76 126.34,77.63 126.34,75.75 130.33,71.77 136.23,71.77 136.61,71.39 146.98,71.39 147.87,72.28 148.02,72.28 v1(148.45,72.71)
  BOTTOM w0.121: v1(148.45,72.71) 148.75,72.4 148.75,52.81 148.88,52.68 150.34,52.68 150.47,52.55 150.47,40.17 150.34,40.04 v1(150.28,40.04)
HDMI_D12: length 73
  TOP w0.121: R290.1 v1(125.89,82.84) ; U10.17 148.91,37.19 150,38.28 v1(150,38.72)
  LY3 w0.102: 130.72,74.66 130.95,74.43
  LY3 w0.133: 130.72,74.66 128.89,76.49 128.89,77.48 129.68,78.27 129.68,78.78 128.89,79.56 128.89,80.24 128.9,80.24 126.3,82.84 v1(125.89,82.84) ; v1(148.07,74.71) 148.07,75.17 147.94,75.3 144.03,75.3 143.25,74.52 143.25,74.51 143.12,74.38 131,74.38 130.95,74.43
  BOTTOM w0.121: v1(150,38.72) 150,39.16 149.82,39.34 149.82,40.36 149.95,40.49 150.1,40.49 150.22,40.61 150.22,50.87 148.66,52.43 148.63,52.43 148.5,52.56 148.5,71.94 148,72.44 148,72.89 148.26,73.15 148.56,73.44 148.56,74.22 v1(148.07,74.71)
HDMI_D13: length 74.6
  TOP w0.121: U10.16 147.76,36.69 147.81,36.73 150.12,36.73 v1(150.25,36.87) ; v1(149.78,47.22) 149.78,46.54 149.43,46.19 143.04,46.19 142.91,46.32 142.91,46.62 142.79,46.75 136.41,46.75 136.28,46.87 136.28,47.79 136.13,47.94 133.92,47.94 133.79,47.81 133.79,47.33 133.67,47.2 131.76,47.2 v1(131.53,47.43) ; v1(125.89,80.81) R291.1
  BOTTOM w0.121: v1(150.25,36.87) 150.25,37.31 149.47,38.09 149.47,40.5 149.9,40.93 149.9,45.67 149.78,45.78 v1(149.78,47.22) ; v1(131.53,47.43) 131.53,50.98 132.57,52.02 132.57,71.82 128.89,75.5 128.89,78.04 128.19,78.74 128.19,79.66 127.04,80.81 v1(125.89,80.81)
HDMI_D14: length 69.2
  TOP w0.121: R293.1 v1(125.89,78.78) ; U10.15 146.68,36.19 146.89,35.98 148.18,35.98 148.23,35.92 148.98,35.92 v1(149.29,36.23)
  LY3 w0.133: v1(125.89,78.78) 126.35,78.78 126.63,78.5 126.63,76.01 128.94,73.7 143.78,73.7 143.98,73.49 145.02,73.49 145.22,73.7 147.6,73.7 147.67,73.63 v1(148.12,73.63)
  BOTTOM w0.121: v1(148.12,73.63) 147.76,73.27 147.76,72.34 148.25,71.85 148.25,52.46 148.91,51.8 148.91,46.29 149.27,45.93 149.29,45.93 149.65,45.57 149.65,41.03 149.22,40.6 149.22,38.34 148.98,38.09 148.98,36.54 v1(149.29,36.23)
HDMI_D15: length 75
  TOP w0.121: v1(146.85,79.84) 146.54,79.53 146.35,79.53 146.08,79.8 144.11,79.8 143.98,79.68 143.98,79.67 143.85,79.54 R294.1 ; v1(148.21,35.34) 147.9,35.66 147.88,35.66 147.85,35.69 U10.14
  BOTTOM w0.121: v1(146.85,79.84) 147.51,79.84 147.74,79.62 147.74,78.77 147.2,78.23 147.2,72.19 147.75,71.64 147.75,53 147.62,52.87 147.43,52.87 147.31,52.74 147.31,46.82 147.43,46.7 148.29,46.7 148.42,46.57 148.42,46.15 147.75,45.49 147.75,43.6 147.74,43.59 147.74,39.23 147.87,39.1 148.27,39.1 148.4,39.23 148.4,42.84 148.75,43.19 149.27,43.19 149.4,43.06 149.4,41.13 148.97,40.7 148.97,38.59 148.85,38.46 147.9,38.46 147.89,38.47 147.26,38.47 147.13,38.59 147.13,41.69 147,41.82 146.67,41.82 146.54,41.69 146.54,37.65 146.67,37.53 148.08,37.53 148.21,37.4 v1(148.21,35.34)
HDMI_D16: length 100.8
  TOP w0.121: U10.13 147.72,35.19 147.83,35.07 147.83,34.69 v1(148.14,34.38) ; 110.53,86.78 v1(110.53,87.72)
  LY3 w0.133: v1(150.15,88.53) 148.04,88.53 147.43,89.14 139.77,89.14 139.28,89.63 118.46,89.63 116.55,87.72 v1(110.53,87.72)
  BOTTOM w0.121: v1(148.14,34.38) 148.2,34.33 148.72,34.33 150.97,36.57 150.97,87.23 150.15,88.04 v1(150.15,88.53)
HDMI_D17: length 118.5
  TOP w0.121: v1(149.9,91.73) 149.01,90.84 141.57,90.84 141.3,91.11 141.3,92.43 141.05,92.68 139.56,92.68 137.58,90.71 137.57,90.71 137.54,90.68 137.16,90.68 v1(137.07,90.59) ; R297.1 v1(98.89,89.88) ; v1(147.08,33.75) 146.64,34.19 U10.11
  BOTTOM w0.121: v1(98.89,89.88) 99.58,89.88 99.7,90 99.7,90.78 99.83,90.91 108.06,90.91 108.31,90.66 111.63,90.66 111.87,90.41 124.87,90.41 125.2,90.08 128.78,90.08 129.37,90.67 131.8,90.67 132.39,90.08 136.44,90.08 136.69,90.33 136.82,90.33 v1(137.07,90.59) ; v1(147.08,33.75) 147.61,34.28 147.61,34.47 147.96,34.82 148.86,34.82 150.72,36.68 150.72,87.12 149.69,88.16 149.69,91.52 v1(149.9,91.73)
HDMI_D18: length 129.2
  TOP w0.121: v1(137.83,102.65) 138.21,102.27 148.14,102.27 148.93,101.48 v1(149.77,101.48) ; R298.1 98.08,94.5 v1(97.78,94.8) ; v1(148.12,33.69) 147.72,33.29 146.74,33.29 146.34,33.69 U10.10
  LY3 w0.133: v1(137.83,102.65) 132.35,102.65 129.91,100.21 125.13,100.21 123.25,98.34 v1(122.59,98.34) 122.57,98.34 122.01,98.89 109.87,98.89 109.05,98.08 103.95,95.42 98.39,95.42 v1(97.78,94.8)
  BOTTOM w0.121: v1(149.77,101.48) 149.77,99.35 150.59,98.53 150.59,88.11 151.21,87.49 151.21,36.47 148.43,33.69 v1(148.12,33.69)
HDMI_D19: length 68.8
  TOP w0.121: v1(152,85.89) 151.93,85.89 151.17,86.65 148.37,86.65 148.12,86.4 147.71,86.4 147.46,86.65 146.77,86.65 146.13,86.02 R299.1 ; v1(148.12,32.54) 148.1,32.54 147.6,33.04 146.62,33.04 146.47,33.19 U10.9
  BOTTOM w0.121: v1(152,85.89) 152,85.83 151.71,85.54 151.71,35.47 148.78,32.54 v1(148.12,32.54)
HDMI_D20: length 69.1
  TOP w0.121: v1(147.11,32.6) 147.03,32.69 U10.8 ; v1(151.93,87.03) 151.49,87.03 151.37,87.15 151.37,87.16 151.27,87.26 146.7,87.26 146.44,87.51 144.26,87.51 143.9,87.16 143.5,87.16 143.37,87.03 R300.1
  BOTTOM w0.121: v1(147.11,32.6) 147.11,33.12 147.24,33.25 148.83,33.25 151.46,35.88 151.46,86.13 151.66,86.33 151.67,86.33 151.93,86.59 v1(151.93,87.03)
HDMI_D21: length 68.9
  TOP w0.121: v1(148.12,31.66) 147.73,31.66 147.23,32.15 145.87,32.15 U10.7 ; R301.1 143.68,83.6 144,83.93 150.96,83.93 151.09,83.8 151.09,83.48 151.22,83.35 151.57,83.35 151.7,83.48 151.7,83.8 151.83,83.93 152.11,83.93 v1(152.56,83.48)
  BOTTOM w0.121: v1(148.12,31.66) 149.26,31.66 152.61,35.01 152.61,81.51 152.3,81.82 152.3,83.22 v1(152.56,83.48)
HDMI_D22: length 69.1
  TOP w0.121: 141.9,84.62 142.79,84.62 143.32,85.15 143.88,85.15 144,85.03 144,84.77 144.13,84.64 144.87,84.64 144.99,84.77 144.99,84.87 145.12,85 v1(152.31,85) ; U10.6 v1(147.08,31.69)
  BOTTOM w0.121: v1(152.31,85) 152.31,84.04 152.06,83.79 152.06,81.71 152.34,81.43 152.34,35.29 149.14,32.1 147.49,32.1 147.08,31.69 v1(147.08,31.69)
HDMI_D23: length 69.2
  TOP w0.121: R303.1 142.18,81.59 142.48,81.89 143.09,81.89 143.42,82.21 152.53,82.21 v1(152.87,81.88) ; v1(148.12,30.77) 147.67,30.33 146.91,30.33 146.55,30.69 U10.4
  BOTTOM w0.121: v1(148.12,30.77) 149.16,30.77 154.71,36.32 154.71,49.06 153.52,50.25 153.52,81.24 152.88,81.88 v1(152.87,81.88)
HDMI_DE: length 87.1
  TOP w0.121: v1(134.66,43.47) 134.66,42.58 136.82,40.42 137.58,40.42 138.13,39.87 U10.33 ; v1(125.77,74.33) 125.26,74.84 125.26,75.48 125.51,75.73 R312.1 ; v1(130.79,47.41) 124.81,47.41 124.68,47.28 124.68,46.87 124.81,46.75 131.12,46.75 131.25,46.62 131.25,45.92 131.37,45.79 134.03,45.79 134.16,45.92 134.16,46.16 134.03,46.29 131.99,46.29 131.86,46.42 131.86,46.75 131.99,46.87 134.03,46.87 134.16,47 134.16,47.56 134.29,47.69 135.03,47.69 v1(135.57,47.15)
  BOTTOM w0.121: v1(134.66,43.47) 134.66,43.91 135.41,44.66 136.41,44.66 136.54,44.79 136.54,48.3 136.41,48.42 135.7,48.42 135.57,48.3 v1(135.57,47.15) ; v1(130.79,47.41) 130.6,47.6 130.6,50.75 132.08,52.22 132.08,60.11 131.95,60.24 131.56,60.24 131.43,60.11 131.43,57.34 131.3,57.21 130.97,57.21 130.85,57.34 130.85,60.93 131.11,61.19 131.11,71.03 130.98,71.16 130.59,71.16 130.47,71.03 130.47,68.49 130.34,68.36 130.02,68.36 129.89,68.49 129.89,72.24 127.61,74.52 126.98,74.52 126.79,74.33 v1(125.77,74.33)
HDMI_EXTSWING: length 1.8
  TOP w0.121: v1(136.94,29.37) 137.13,29.19 U10.56
  BOTTOM w0.381: v1(136.94,29.37) 136.82,29.25 R292.2
HDMI_HPLG: length 41.5
  TOP w0.121: U10.54 135.23,29.19 134.56,28.51 R569.2 132.73,28.97 132.78,29.02 v1(132.78,29.45) ; v1(130.75,35.9) 129.86,35.9 126.28,32.32 126.28,22.27 132.06,16.49 132.43,16.49 132.59,16.65 U11.4
  BOTTOM w0.121: v1(132.78,29.45) 131.46,30.77 131.46,34.35 130.75,35.06 v1(130.75,35.9)
HDMI_HSYNC: length 70.6
  TOP w0.121: v1(127.16,74.08) 126.66,74.59 R311.1 ; v1(130.39,46.21) 131.25,45.35 v1(133.51,45.35) ; v1(133.51,43.47) 133.51,42.46 136.39,39.58 137.46,39.58 137.63,39.41 U10.34
  BOTTOM w0.121: v1(127.16,74.08) 127.16,73.44 127.29,73.32 128.46,73.32 128.59,73.19 128.59,72.94 128.46,72.81 127.29,72.81 127.16,72.68 127.16,72.3 127.29,72.17 128.31,72.17 128.43,72.05 128.43,67.09 128.56,66.97 128.94,66.97 129.07,67.09 129.07,72.05 129.2,72.17 129.45,72.17 129.58,72.05 129.58,61.76 129.7,61.63 130.09,61.63 130.21,61.76 130.21,67.98 130.34,68.11 130.72,68.11 130.85,67.98 130.85,61.51 130.35,61.01 130.35,46.25 v1(130.39,46.21) ; v1(133.51,45.35) v1(133.51,43.47)
HDMI_I2C_SCL: length 109.7
  TOP w0.121: U10.1 146.4,29.19 146.85,28.74 v1(148.37,28.74) ; v1(158.36,99.33) 157.16,99.33 157.11,99.28 152.23,99.28 151.35,98.4 150.98,98.4 149.71,99.67 144.47,99.67 144.29,99.49 139.19,99.49 137.02,97.32 131.53,97.32 130.21,96 R313.1
  BOTTOM w0.121: v1(148.37,28.74) 148.75,29.12 148.75,29.95 159.49,40.68 159.49,98.19 v1(158.36,99.33)
HDMI_I2C_SDA: length 190.8
  TOP w0.121: v1(160.31,55.92) 159.87,56.36 158.69,56.36 157.79,55.46 152.77,55.46 151.87,56.36 132.76,56.36 130.85,58.26 128.84,58.26 128.77,58.33 123.22,58.33 122.03,57.14 120.59,57.14 116.58,53.13 116.4,52.95 110.15,52.95 109.95,52.75 109.51,52.75 109.09,52.33 106.49,52.33 105.91,51.74 104.45,51.74 104.24,51.95 87.19,51.95 87.09,52.05 77.47,52.05 75.52,54 74.16,54 73.26,54.9 65.39,54.9 63.99,56.3 62.04,56.3 59.21,59.12 59.21,59.16 v1(58.9,59.47) ; R314.1 67.35,93.76 67,93.59 66.92,93.51 66.5,93.51 66.34,93.67 66.17,93.67 65.63,94.21 64.84,94.21 64.02,95.03 60.93,95.03 v1(60.11,94.21) ; v1(149.29,29.63) 148.91,29.25 146.85,29.25 146.41,29.69 U10.2
  BOTTOM w0.121: v1(160.31,55.92) 160.31,40.68 149.29,29.65 v1(149.29,29.63) ; v1(58.9,59.47) 58.9,69.16 61.52,71.78 62.62,72.87 62.62,80.97 62.23,81.35 62.23,81.41 62.21,81.44 62.21,82.85 61.57,83.48 61.57,86.39 60.85,87.11 60.85,88.11 59.71,89.25 59.71,91.97 59.8,92.06 59.8,93.32 60.11,93.63 v1(60.11,94.21)
HDMI_I2CSCL: length 30.7
  TOP w0.121: U10.49 134.53,31.69 133.67,32.55 R567.1 132.17,33.08 129.19,33.08 127.23,31.11 127.23,22.83 132.11,17.95 U11.2
HDMI_I2CSDA: length 33
  TOP w0.121: U10.48 134.86,32.19 133.21,33.84 R568.1 132.09,34.45 129.88,34.45 126.75,31.33 126.75,22.8 132.18,17.37 132.43,17.37 132.5,17.3 U11.3
HDMI_INTN: length 151.4
  TOP w0.121: U10.52 135.92,30.2 134.61,30.2 134.51,30.29 v1(133.9,30.29) R570.1 ; v1(59.55,96.12) 59.83,96.4 R324.1
  LY3 w0.133: v1(133.9,30.29) 136.33,32.73 136.33,44.16 135.71,44.78 127.13,44.78 125.89,46.01 125.89,50.97 124.88,51.98 124.88,52.75 124.37,53.25 117.39,53.25 112.28,48.14 98.51,48.14 98.38,48.28 98.28,48.28 98.01,48.54 98.01,48.64 97.6,49.06 65.42,49.06 64.45,48.09 v1(63.89,48.09)
  LY4 w0.133: v1(59.55,96.12) 59.55,82.92 60.68,81.78 60.68,54.83 61.38,54.14 61.38,50.61 v1(63.89,48.09)
HDMI_IOVCC: length 34.3
  TOP w0.305: v1(147.1,29.76) 146.98,29.76 146.54,30.19 U10.3 ; U10.21 v1(144.13,39.23) ; v1(135.04,33.44) 135.29,33.19 U10.46
  TOP w0.508: v1(164.88,23.41) v1(164.88,22.26) FB12.1 ; v1(147.1,29.76) 147.99,29.76 v1(148.12,29.88)
  BOTTOM w0.508: C152.1 144.13,38.57 v1(144.13,39.23) ; C151.1 146.34,29.76 v1(147.1,29.76) 147.99,29.76 ; v1(164.88,22.26) v1(164.88,23.41) 163.99,24.29 149.39,24.29 147.61,26.07 147.61,28.88 147.99,29.26 147.99,29.76 ; 147.99,29.76 v1(148.12,29.88) ; v1(135.04,33.44) 135.29,33.69 C150.1
HDMI_LSOE: length 4.2
  TOP w0.121: v1(136.18,16.17) 136.35,16 U11.5
  BOTTOM w0.121: R322.1 137.45,14.9 v1(136.18,16.17)
HDMI_PCLK: length 69.5
  TOP w0.121: v1(146.09,43.47) 146.09,40.6 145.27,39.79 143.9,39.79 143.63,39.52 U10.22 ; v1(144.94,48.92) 145.08,49.06 147.13,49.06 147.26,49.19 147.26,52.03 147.13,52.16 135.83,52.16 133.51,49.85 v1(131.04,49.85) ; R307.1 126.02,76.75 125.89,76.87 v1(125.39,76.87)
  BOTTOM w0.121: v1(125.39,76.87) 126.28,76.87 126.66,77.25 127.93,77.25 128.29,76.89 128.29,74.7 131.69,71.3 131.69,62.51 132.32,61.88 132.32,52.12 131.04,50.84 v1(131.04,49.85) ; v1(144.94,48.92) 144.49,48.47 144.49,47.74 146.09,46.14 v1(146.09,43.47)

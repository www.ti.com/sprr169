# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_LAYOUT_REV1_6A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AM335X_MCASP0_AXR0: length 145.4
  TOP w0.102: v2(81,87.4) U2.D12
  TOP w0.121: 29.5,124.75 34.58,124.75 38.91,120.43 68.04,120.43 68.36,120.75 73.13,120.75 74.92,122.55 78.23,122.55 78.53,122.85 v1(79.03,122.85) ; v1(78.08,154.15) 81.56,154.15 81.63,154.08 84.45,154.08 84.69,153.84 85.31,153.84 85.55,154.08 86.05,154.08 87.54,155.57 R451.1
  LY4 w0.133: v1(69.32,98.91) 70.01,99.61 70.01,110.48 71,111.47 71,114.82 v1(79.03,122.85)
  BOTTOM w0.102: 77.05,89.47 78.94,89.47 79.03,89.38 79.6,89.38 79.79,89.19 79.79,88.75 79.92,88.62 80.04,88.62 80.04,88.62 80.36,88.62 80.58,88.4 80.58,88.02 81,87.6 v2(81,87.4)
  BOTTOM w0.121: v1(69.32,98.91) 69.32,98.27 68.97,97.93 68.97,96.1 68.97,96.08 68.97,95.6 69.36,95.2 69.36,94.53 70.74,93.15 70.74,92.29 73.56,89.47 77.05,89.47 ; v1(78.08,154.15) 77.53,153.61 77.53,147.97 77.33,147.76 77.33,136.97 78.03,136.27 78.03,135.03 77.91,134.92 77.91,134.1 78.97,133.04 78.97,125.25 79.26,124.96 79.26,123.56 79.61,123.21 79.61,123.2 79.64,123.17 79.65,123.17 79.92,122.9 R203.1 v1(79.03,122.85)
AM335X_MCASP0_AXR1: length 110.1
  TOP w0.102: v2(80.2,88.2) U2.D13
  TOP w0.121: R348.1 50.02,128.11 39.86,128.11 v1(38.52,129.45)
  LY3 w0.133: v1(33.79,87.41) 34.11,87.73 55.15,87.73 57.73,90.3 62.36,90.3 65.32,93.26 v1(70.01,93.26)
  BOTTOM w0.102: 77.1,88.98 78.61,88.98 78.97,88.62 79.63,88.62 79.84,88.42 80,88.42 80.2,88.21 v2(80.2,88.2)
  BOTTOM w0.121: 77.1,88.98 73.35,88.98 70.19,92.14 70.18,92.14 69.84,92.48 69.84,93 70.01,93.18 v1(70.01,93.26) ; v1(38.52,129.45) 38.04,128.97 37.4,128.97 35.85,127.42 35.85,113.5 34.4,112.05 34.4,107.42 34.41,107.41 34.41,107.04 34.4,107.03 34.4,98.49 33.46,97.55 33.46,87.74 v1(33.79,87.41)
AM335X_MCASP0_FSR: length 29.9
  TOP w0.102: v2(79.4,88.2) U2.C13
  TOP w0.121: R336.1 70.65,104.3 v1(69.44,104.3)
  BOTTOM w0.102: 77.1,88.73 77.81,88.73 78.35,88.2 v2(79.4,88.2)
  BOTTOM w0.121: v1(69.44,104.3) 69.19,104.05 69.19,100.88 68.76,100.45 68.76,99.73 68.87,99.61 68.87,98.34 68.72,98.18 68.72,96.11 68.72,96.09 68.72,95.5 68.93,95.29 68.93,95.26 69.12,95.08 69.12,94.49 68.77,94.14 68.77,92.29 69.13,91.93 70.04,91.93 70.3,91.67 70.3,91.25 71.48,90.07 71.91,90.07 73.25,88.73 77.1,88.73
AM335X_MCASP0_FSX: length 58.8
  TOP w0.102: U2.B13 78.63,88.18 77.63,88.18 77.1,88.7
  TOP w0.121: v1(69.69,90.34) 69.88,90.14 74.78,90.14 75.75,89.17 76.64,89.17 77.1,88.7 ; v1(81,119.73) 75.98,119.73 74.5,118.25 67.89,118.25 v1(67.16,117.51) ; R335.1 v1(82.46,121.83)
  BOTTOM w0.121: v1(81,119.73) 81.32,120.05 81.32,120.69 v1(82.46,121.83) R199.1 ; v1(67.16,117.51) 67.16,116.56 68.66,115.06 68.66,112.71 68.8,112.56 68.8,111 68.94,110.86 68.94,104.16 68.94,104.15 68.94,101.38 68.51,100.95 68.51,98.5 68.47,98.46 68.47,96.12 68.44,95.4 68.87,94.97 68.87,94.6 68.52,94.25 68.52,91.04 69.22,90.34 v1(69.69,90.34)
AM335X_MMC2_CLK: length 2.3
  TOP w0.121: R459.1 19.37,108.9 19.37,109.21 19.49,109.33 20,109.33 20.46,108.87 U28.9
AM335X_MMC2_CMD: length 2.3
  TOP w0.121: U28.4 22.77,111.39 22.39,111.77 22.39,112.18 R460.1
AM335X_MMC2_D0: length 126.3
  TOP w0.121: U28.6 21.77,110.89 20.42,112.24 20.42,113.95 v1(20.81,114.34)
  LY3 w0.133: v1(106.23,120.58) 105.74,121.07 105.62,121.07 105.55,121.14 82.49,121.14 81.73,121.9 75.27,121.9 74.05,120.67 73.29,120.67 73.16,120.55 73.16,119.7 73.04,119.58 71.87,119.58 71.74,119.7 71.74,120.55 71.61,120.67 70.73,120.67 70.6,120.55 70.6,119.7 70.47,119.58 69.18,119.58 69.06,119.7 69.06,120.55 68.93,120.67 53.07,120.67 51.58,119.18 39.81,119.18 34.94,114.32 25.48,114.32 25.18,114.62 24.4,114.62 24.25,114.76 21.24,114.76 v1(20.81,114.34)
  BOTTOM w0.121: R456.1 104.55,95.35 105.58,95.35 106.7,96.48 106.7,117.09 107.41,117.79 107.41,119.99 106.82,120.58 v1(106.23,120.58)
AM335X_MMC2_D1: length 126.6
  TOP w0.121: U28.7 21.05,111.05 20.05,112.05 v1(20.05,114.36)
  LY3 w0.133: v1(107.74,120.28) 107.73,120.28 106.61,121.4 83.52,121.4 82.65,122.28 74.92,122.28 74.54,121.9 70.88,121.9 70.58,121.6 70.57,121.6 70.27,121.3 68.39,121.3 68.11,121.58 67.54,121.58 66.9,120.93 52.96,120.93 51.47,119.44 39.7,119.44 34.84,114.58 25.59,114.58 25.25,114.92 24.5,114.92 24.33,115.1 20.79,115.1 v1(20.05,114.36)
  BOTTOM w0.121: R457.1 103.53,95.11 105.68,95.11 106.95,96.38 106.95,116.99 107.74,117.77 v1(107.74,120.28)
AM335X_MMC2_D2: length 126.1
  TOP w0.121: v1(25.06,114.08) 24.93,113.96 24.93,111.67 24.27,111.02 U28.1
  LY3 w0.133: v1(25.06,114.08) 25.11,114.08 25.31,113.88 34.87,113.88 39.91,118.92 51.69,118.92 53.18,120.41 68.67,120.41 68.79,120.29 68.79,119.98 68.67,119.85 63.77,119.85 63.64,119.72 63.64,119.44 63.77,119.32 73.24,119.32 75.39,121.46 81.72,121.46 82.48,120.7 87.81,120.7 87.99,120.88 105.22,120.88 105.98,120.13 106.64,120.13 v1(106.96,119.8)
  BOTTOM w0.121: R458.1 106.46,97 106.46,117.19 107.16,117.89 107.16,119.61 v1(106.96,119.8)
AM335X_MMC2_D3: length 2.2
  TOP w0.121: R491.1 23.91,112.48 23.27,111.84 U28.3
AM335X_MMC_CLK: length 64.9
  TOP w0.102: U2.G17 82.65,91.35 82.65,92.9
  TOP w0.121: v1(82.82,96) 82.82,95.92 83.21,95.53 83.21,94.16 83.16,94.12 83.16,94.1 82.65,93.59 82.65,92.9
  BOTTOM w0.121: v1(82.82,96) 82.82,96.31 83.22,96.71 83.22,97.24 83.22,97.45 83.07,97.6 83.07,98.2 82.89,98.38 81.73,99.54 81.73,100.81 81.4,101.14 81.4,106.03 81.39,106.04 80.76,106.67 80.76,118.49 80.75,118.49 80.75,118.7 80.76,118.76 82.01,120.02 82.01,120.49 83.56,122.04 83.56,129.67 83.43,129.79 82.81,129.79 82.69,129.91 82.69,130.15 82.81,130.27 83.43,130.27 83.56,130.39 83.56,130.63 83.43,130.75 82.81,130.75 82.69,130.88 82.69,131.12 82.81,131.24 83.43,131.24 83.56,131.36 83.56,131.6 83.43,131.72 82.81,131.72 82.69,131.84 82.69,132.08 82.81,132.2 83.43,132.2 83.56,132.32 83.56,132.56 83.43,132.69 82.81,132.69 82.69,132.81 82.69,133.05 82.81,133.17 83.43,133.17 83.56,133.29 83.56,133.53 83.43,133.65 82.81,133.65 82.69,133.77 82.69,134.01 82.81,134.13 83.43,134.13 83.56,134.25 83.56,134.5 83.43,134.62 82.81,134.62 82.69,134.74 82.69,134.98 82.81,135.1 83.43,135.1 83.56,135.22 83.56,135.47 82.71,136.31 82.71,142.66 R398.2
AM335X_MMC_CMD: length 78.7
  TOP w0.102: U2.G18 83,92.9
  TOP w0.121: v1(85.86,143.52) 85.42,143.52 85.27,143.67 82.52,143.67 82.39,143.55 v1(81.95,143.55) ; v1(83.1,93.41) 83,93.31 83,92.9
  BOTTOM w0.121: v1(83.1,93.41) 83.1,93.41 83.58,93.89 83.88,93.89 85.79,95.8 85.79,102 85.6,102.19 85.6,102.56 86.38,103.34 86.39,103.34 86.39,114.46 87.03,115.11 87.03,116 87.04,116.01 87.04,116.37 87.03,116.38 87.03,122.46 88.76,124.19 88.76,126.34 88.88,126.46 90.09,126.46 90.21,126.58 90.21,126.82 90.09,126.94 88.88,126.94 88.76,127.06 88.76,127.3 88.88,127.42 90.09,127.42 90.21,127.55 90.21,127.79 90.09,127.91 88.88,127.91 88.76,128.03 88.76,128.27 88.88,128.39 90.09,128.39 90.21,128.51 90.21,128.75 90.09,128.87 88.88,128.87 88.76,128.99 88.76,129.23 88.88,129.35 90.09,129.35 90.21,129.48 90.21,129.72 90.09,129.84 88.88,129.84 88.76,129.96 88.76,130.2 88.88,130.32 90.09,130.32 90.21,130.44 90.21,130.68 90.09,130.8 88.88,130.8 88.76,130.92 88.76,131.16 88.88,131.29 90.09,131.29 90.21,131.41 90.21,131.65 90.09,131.77 88.88,131.77 88.76,131.89 88.76,132.13 88.88,132.25 90.09,132.25 90.21,132.37 90.21,132.61 90.09,132.73 88.88,132.73 87.39,134.23 87.39,140.19 85.86,141.72 v1(85.86,143.52) ; R200.2 v1(81.95,143.55)
AM335X_MMC_D0: length 60.5
  TOP w0.102: v2(82.6,90.6) U2.G16
  BOTTOM w0.102: 82.6,93.8 v2(82.6,90.6)
  BOTTOM w0.121: R204.2 79.15,143.45 79.18,143.42 79.77,143.42 80.36,142.83 80.36,140.81 80.24,140.69 80.24,136.24 81.26,135.22 81.26,133.6 81.63,133.23 82.26,133.23 82.38,133.11 82.38,132.87 82.26,132.75 81.63,132.75 81.51,132.63 81.51,132.38 81.63,132.26 82.26,132.26 82.38,132.14 82.38,131.9 82.26,131.78 81.63,131.78 81.51,131.66 81.51,125.12 81.77,124.85 81.77,122.41 80.5,121.14 80.5,107.03 80.5,106.58 80.85,106.23 81.15,105.92 81.15,101.62 81.15,101.04 81.48,100.71 81.48,99.64 81.48,99.44 82.83,98.1 82.83,97.49 82.97,97.34 82.97,96.84 82.05,95.92 82.05,94.34 82.6,93.8
AM335X_MMC_D1: length 72.8
  TOP w0.102: v2(82.6,89.8) U2.G15
  TOP w0.121: v1(71.79,143.45) 72.39,142.85 80.1,142.85 80.16,142.79 80.94,142.79 82.37,141.35 83.31,141.35 83.73,141.77 84.41,141.77 84.44,141.74 v1(84.82,141.74)
  LY4 w0.133: v1(82.16,116.12) 82.16,114.31 81.76,113.91 81.76,108.13 83.63,106.26 83.63,104.79 v1(86.04,102.37)
  BOTTOM w0.102: 83.32,92.9 83.02,92.59 83.02,90.22 v2(82.6,89.8)
  BOTTOM w0.121: v1(84.82,141.74) 84.82,140.21 84.93,140.11 84.93,129.78 85.95,128.75 85.95,124.76 84.75,123.56 84.75,121.98 83.58,120.81 83.58,119.16 82.16,117.74 v1(82.16,116.12) ; R400.2 v1(71.79,143.45) ; v1(86.04,102.37) 86.04,95.54 84.34,93.84 84.26,93.84 83.32,92.9
AM335X_MMC_D2: length 89.5
  TOP w0.102: U2.F18 82.4,92 82.4,93.1
  TOP w0.121: v1(82.42,97.09) 82.42,96.47 82.33,96.38 82.33,94.74 82.4,94.66 82.4,93.1 ; v1(69.23,143.45) 67.14,143.45 67.02,143.32 67.02,142.53 67.14,142.4 67.23,142.4 67.35,142.28 67.35,141.64 67.47,141.52 67.71,141.52 67.83,141.64 67.83,142.28 67.95,142.4 68.19,142.4 68.32,142.28 68.32,141.64 68.44,141.52 68.68,141.52 68.8,141.64 68.8,142.28 68.92,142.4 69.16,142.4 69.28,142.28 69.28,141.64 69.4,141.52 69.64,141.52 69.76,141.64 69.76,142.28 69.88,142.4 70.37,142.4 70.49,142.28 70.49,141.57 70.61,141.45 70.85,141.45 70.97,141.57 70.97,142.28 71.1,142.4 71.34,142.4 71.46,142.28 71.46,141.57 71.58,141.45 71.82,141.45 71.94,141.57 71.94,142.28 72.06,142.4 72.3,142.4 72.42,142.28 72.42,141.57 72.54,141.45 72.78,141.45 72.9,141.57 72.9,142.28 73.03,142.4 73.27,142.4 73.39,142.28 73.39,141.57 73.51,141.45 73.75,141.45 73.87,141.57 73.87,142.28 73.99,142.4 74.23,142.4 74.35,142.28 74.35,141.57 74.47,141.45 74.71,141.45 74.84,141.57 74.84,142.28 74.96,142.4 75.2,142.4 75.32,142.28 75.32,141.57 75.44,141.45 75.68,141.45 75.8,141.57 75.8,142.28 75.92,142.4 76.16,142.4 76.28,142.28 76.28,141.57 76.4,141.45 76.65,141.45 76.77,141.57 76.77,142.28 76.89,142.4 77.13,142.4 77.25,142.28 77.25,141.57 77.37,141.45 77.61,141.45 77.73,141.57 77.73,142.28 77.85,142.4 78.09,142.4 78.21,142.28 78.21,141.57 78.33,141.45 78.58,141.45 78.7,141.57 78.7,142.28 78.82,142.4 v1(79.92,142.4)
  BOTTOM w0.121: v1(82.42,97.09) 81.44,98.06 81.44,98.71 80.87,99.28 80.87,100.62 80.64,100.85 80.64,105.73 80.01,106.37 80.01,106.83 80.01,107.3 79.38,107.93 79.38,120.78 80.56,121.96 80.56,124.75 81.02,125.21 81.02,129.75 80.37,130.4 80.37,134.77 v1(80.31,134.83) 80.31,135.28 79.67,135.92 79.67,141.25 79.41,141.51 79.41,141.9 v1(79.92,142.4) ; R401.2 v1(69.23,143.45)
AM335X_MMC_D3: length 86.9
  TOP w0.102: 81.89,91.97 81.89,91.96 81.87,91.94 81.87,91.31 82.18,91 U2.F17
  TOP w0.121: v1(79.92,141.62) 79.83,141.62 79.41,141.2 79.13,141.2 79.01,141.08 79.01,140.93 78.89,140.81 78.65,140.81 78.53,140.93 78.53,141.08 78.41,141.2 78.16,141.2 78.04,141.08 78.04,140.93 77.92,140.81 77.68,140.81 77.56,140.93 77.56,141.08 77.44,141.2 77.2,141.2 77.08,141.08 77.08,140.93 76.96,140.81 76.72,140.81 76.6,140.93 76.6,141.08 76.48,141.2 76.23,141.2 76.11,141.08 76.11,140.93 75.99,140.81 75.75,140.81 75.63,140.93 75.63,141.08 75.51,141.2 75.27,141.2 75.15,141.08 75.15,140.93 75.03,140.81 74.79,140.81 74.67,140.93 74.67,141.08 74.55,141.2 74.3,141.2 74.18,141.08 74.18,140.93 74.06,140.81 73.82,140.81 73.7,140.93 73.7,141.08 73.58,141.2 73.34,141.2 73.22,141.08 73.22,140.93 73.1,140.81 72.86,140.81 72.74,140.93 72.74,141.08 72.61,141.2 72.37,141.2 72.25,141.08 72.25,140.93 72.13,140.81 71.89,140.81 71.77,140.93 71.77,141.08 71.65,141.2 71.41,141.2 71.29,141.08 71.29,140.93 71.17,140.81 70.93,140.81 70.81,140.93 70.81,141.08 70.68,141.2 70.44,141.2 70.32,141.08 70.32,140.93 70.2,140.81 69.96,140.81 69.84,140.93 69.84,141.08 69.72,141.2 69.48,141.2 69.36,141.08 69.36,140.93 69.24,140.81 69,140.81 68.87,140.93 68.87,141.08 68.75,141.2 67.05,141.2 66.36,141.9 v1(66.36,142.94) ; v1(82.38,97.79) 82.18,97.59 82.18,97.48 81.97,97.27 81.97,94.74 82.16,94.56 82.16,92.24 81.89,91.97
  BOTTOM w0.121: v1(79.92,141.62) 79.99,141.55 79.99,135.98 80.81,135.16 80.81,134.65 80.62,134.45 80.62,130.67 81.26,130.02 81.26,122.28 79.63,120.65 79.63,120.4 79.75,120.28 80.13,120.28 80.25,120.16 80.25,119.92 80.13,119.8 79.75,119.8 79.63,119.68 79.63,119.44 79.75,119.32 80.13,119.32 80.25,119.19 80.25,118.95 80.13,118.83 79.75,118.83 79.63,118.71 79.63,118.47 79.75,118.35 80.13,118.35 80.25,118.23 80.25,117.99 80.13,117.87 79.75,117.87 79.63,117.75 79.63,117.51 79.75,117.39 80.13,117.39 80.25,117.26 80.25,117.02 80.13,116.9 79.75,116.9 79.63,116.78 79.63,116.54 79.75,116.42 80.13,116.42 80.25,116.3 80.25,116.06 80.13,115.94 79.75,115.94 79.63,115.82 79.63,115.58 79.75,115.45 80.13,115.45 80.25,115.33 80.25,115.09 80.13,114.97 79.75,114.97 79.63,114.85 79.63,114.61 79.75,114.49 80.13,114.49 80.25,114.37 80.25,114.13 80.13,114.01 79.75,114.01 79.63,113.89 79.63,113.64 79.75,113.52 80.13,113.52 80.25,113.4 80.25,113.16 80.13,113.04 79.75,113.04 79.63,112.92 79.63,112.68 79.75,112.56 80.13,112.56 80.25,112.44 80.25,112.2 80.13,112.08 79.75,112.08 79.63,111.96 79.63,111.71 79.75,111.59 80.13,111.59 80.25,111.47 80.25,111.23 80.13,111.11 79.75,111.11 79.63,110.99 79.63,110.75 79.75,110.63 80.13,110.63 80.25,110.51 80.25,110.27 80.13,110.15 79.75,110.15 79.63,110.03 79.63,109.78 79.75,109.66 80.13,109.66 80.25,109.54 80.25,109.3 80.13,109.18 79.75,109.18 79.63,109.06 79.63,108.03 80.25,107.4 80.25,106.93 80.25,106.47 80.89,105.84 80.89,100.95 81.24,100.6 81.24,99.75 81.24,99.3 81.88,98.66 81.88,98.3 v1(82.38,97.79) ; v1(66.36,142.94) 66.36,143.29 66.46,143.39 R219.2
AM335X_OSC0_IN: length 20.2
  TOP w0.102: U2.V10 92.47,85.4 92.78,85.1 94.38,85.1
  TOP w0.121: Y2.3 106.97,78.65 106.97,79.92 106.74,80.15 C4.1 101.41,80.76 101.41,80.94 R7.2 99.85,82.49 99.85,84.18 98.45,85.58 94.86,85.58 94.38,85.1
AM335X_OSC0_OUT: length 11.4
  TOP w0.121: U2.U11 91.43,86.63 91.91,86.63 92.04,86.76 92.95,86.76 93.37,87.17 94.36,87.17 95.32,86.21 98.78,86.21 100.06,84.93 100.52,84.93 R8.1
AM335X_OSC1_IN: length 15.2
  TOP w0.102: U2.A6 77.97,81.97 77.74,81.97
  TOP w0.121: Y1.4 64.93,79.11 65.71,79.9 65.86,79.9 66.71,80.74 C2.2 67.42,80.77 67.45,80.8 68.46,80.8 68.83,80.43 71.12,80.43 71.35,80.66 72.66,80.66 73.32,81.32 75.69,81.32 76.01,81.64 76.42,81.64 76.43,81.63 77.2,81.63 77.22,81.6 77.36,81.6 77.74,81.97
AM335X_OSC1_OUT: length 8.5
  TOP w0.102: 77.1,80.89 77.91,80.89 U2.A4
  TOP w0.121: R5.1 70.84,79.41 70.95,79.53 71.27,79.53 71.66,79.91 75.34,79.91 76.32,80.89 77.1,80.89
AM335X_PORZ: length 31.8
  TOP w0.102: U2.B15 79,89.41 78.54,89.87 78.06,89.87
  TOP w0.121: v1(76.36,90.53) 76.67,90.22 76.99,90.22 77.33,89.87 78.06,89.87 ; v1(70.62,100.19) 70.62,99.58 70.52,99.48 R9.2 69.69,99.8 69.69,100.05 69.69,100.05 69.69,100.1 69.4,100.39 68.57,100.39 67.36,99.19 65.02,99.19 64.16,98.34 63.76,98.34 63.28,98.82 61.96,98.82 v1(61.81,98.97)
  LY4 w0.133: v1(61.81,98.97) 62.13,99.29 62.29,99.29 63.16,100.16 63.16,101.12 62.78,101.51 v1(62.78,102.07)
  BOTTOM w0.121: R2.1 v1(62.78,102.07) ; v1(76.36,90.53) 75.92,90.97 75.73,90.97 74.33,92.37 74.33,93.08 73.19,94.22 73.19,97.57 72.55,98.21 71.86,98.21 71.47,98.59 71.47,99.86 71.14,100.19 v1(70.62,100.19)
AM335X_RTC_PORZ: length 50
  TOP w0.102: 76.32,81.39 77.49,81.39 77.86,81.76 78.65,81.76 79,81.41 U2.B5
  TOP w0.121: U1.4 53.7,103.05 53.5,102.85 53.5,99.88 54.06,99.33 56.43,99.33 57.11,98.64 v1(59.6,98.64) ; 76.32,81.39 76.12,81.39 75.79,81.06 73.44,81.06 72.79,80.41 71.45,80.41 71.22,80.17 68.73,80.17 68.55,80.36 v1(68.11,80.36)
  LY3 w0.133: v1(61.93,80.68) 61.93,80.64 62.21,80.36 v1(68.11,80.36)
  BOTTOM w0.121: v1(61.93,80.68) 61.71,80.9 61.71,82.64 61.08,83.28 61.08,86.18 60.79,86.47 60.36,86.91 60.36,87.52 60.36,87.52 60.36,87.91 59.22,89.05 59.22,92.18 59.3,92.27 59.3,93.56 59.3,93.56 59.3,94.48 60.08,95.26 60.08,98.16 v1(59.6,98.64) 60.54,99.58 60.77,99.58 R4.2
AM335X_SPI0_CS0: length 107
  TOP w0.102: v2(77.3,90.46) 77.48,90.28 78.12,90.28 U2.A16
  TOP w0.121: R313.2 131.36,95.29 v1(131.86,95.8)
  LY3 w0.133: v1(119.82,108.7) 119.52,109 119.52,109.97 119.1,110.39 118.72,110.39 118.63,110.3 108.98,110.3 108.04,111.24 101.08,111.24 100.27,112.04 90.57,112.04 89.6,113.01 87.59,113.01 87.34,113.26 86.97,113.26 86.68,112.97 77.84,112.97 77.3,112.43 v1(69.86,112.43)
  BOTTOM w0.102: 77.1,90.44 77.13,90.46 v2(77.3,90.46)
  BOTTOM w0.121: 77.1,90.44 76.75,90.08 75.73,90.08 73.83,91.98 73.83,92.82 72.69,93.96 72.69,94 72.68,94.02 72.68,95.67 R552.1 72.94,96.94 72.94,97.48 72.51,97.91 71.81,97.91 71.09,98.62 71.09,99.42 70.76,99.75 70.44,99.75 70.18,100.01 70.18,100.6 70.01,100.77 70.01,103.48 70.38,103.85 70.38,105.79 69.69,106.48 69.69,111.31 69.86,111.49 v1(69.86,112.43) ; v1(119.82,108.7) 120.36,108.7 120.63,108.43 120.63,97.56 122.83,95.36 130.41,95.36 130.85,95.8 v1(131.86,95.8)
AM335X_SPI0_CS1: length 10.4
  TOP w0.102: v2(79.4,89.8) U2.C15
  TOP w0.121: v1(73.01,90.83) 73.02,90.84 73.02,91.16 72.61,91.56 72.61,91.82 72.3,92.13 R380.2 72.29,92.19 71.33,92.19 R78.2
  BOTTOM w0.102: 77.1,89.72 79.32,89.72 v2(79.4,89.8)
  BOTTOM w0.121: 77.1,89.72 73.73,89.72 73.01,90.44 v1(73.01,90.83)
AM335X_SPI0_D0: length 106.7
  TOP w0.102: U2.B17 78.65,91.35 77.1,91.35
  TOP w0.121: R205.1 79.67,133.77 79.79,133.64 81.26,133.64 81.39,133.51 81.39,133.23 80.02,131.86 74.27,131.86 74.08,132.05 74.08,132.24 74.27,132.43 79.09,132.43 79.22,132.56 79.22,133.64 79.09,133.77 78.05,133.77 77.93,133.65 77.93,132.9 77.81,132.78 77.57,132.78 77.45,132.9 77.45,133.65 77.33,133.77 77.08,133.77 76.96,133.65 76.96,132.9 76.84,132.78 76.6,132.78 76.48,132.9 76.48,133.65 76.36,133.77 75.04,133.77 74.92,133.64 74.92,133.39 74.79,133.26 v1(74.36,133.26) ; v1(73.88,95.13) 74.33,94.69 74.33,92.3 75.01,91.63 76.82,91.63 77.1,91.35
  BOTTOM w0.121: v1(73.88,95.13) 73.88,96.93 74.52,97.57 74.52,97.84 76.1,99.42 76.1,103.29 75.98,103.42 75.98,106.8 76.1,106.92 77.07,106.92 77.19,107.04 77.19,107.28 77.07,107.41 76.1,107.41 75.98,107.53 75.98,107.77 76.1,107.89 77.07,107.89 77.19,108.01 77.19,108.25 77.07,108.37 76.1,108.37 75.98,108.49 75.98,108.93 76.1,109.05 76.97,109.05 77.09,109.17 77.09,109.41 76.97,109.53 76.1,109.53 75.98,109.65 75.98,109.9 76.1,110.02 76.97,110.02 77.09,110.14 77.09,110.38 76.97,110.5 76.1,110.5 75.98,110.62 75.98,110.86 76.1,110.98 76.97,110.98 77.09,111.1 77.09,111.34 76.97,111.46 76.1,111.46 75.98,111.58 75.98,111.83 76.1,111.95 76.97,111.95 77.09,112.07 77.09,112.31 76.97,112.43 76.1,112.43 75.98,112.55 75.98,112.79 76.1,112.91 76.97,112.91 77.09,113.03 77.09,113.27 76.97,113.39 76.1,113.39 75.98,113.52 75.98,113.76 76.1,113.88 76.97,113.88 77.09,114 77.09,114.24 76.97,114.36 76.1,114.36 75.98,114.48 75.98,114.72 76.1,114.84 76.97,114.84 77.09,114.96 77.09,115.2 76.97,115.32 76.1,115.32 75.98,115.45 75.98,115.69 76.1,115.81 76.97,115.81 77.09,115.93 77.09,116.17 76.97,116.29 76.1,116.29 75.98,116.41 75.98,116.65 76.1,116.77 76.97,116.77 77.09,116.89 77.09,117.13 76.97,117.26 76.1,117.26 75.98,117.38 75.98,118.23 76.1,118.35 76.75,118.35 76.87,118.47 76.87,118.71 76.75,118.83 76.1,118.83 75.98,118.95 75.98,119.84 75.29,120.53 75.29,120.63 73.5,122.42 73.5,129.65 73.37,129.77 72.68,129.77 72.55,129.9 72.55,130.55 72.68,130.67 74.6,130.67 74.72,130.79 74.72,131.04 74.6,131.16 71.89,131.16 71.77,131.28 71.77,131.51 71.89,131.64 74.6,131.64 74.72,131.76 74.72,132 74.6,132.12 73.93,132.12 73.81,132.24 73.81,132.71 v1(74.36,133.26)
AM335X_SPI0_D1: length 15
  TOP w0.102: 77.83,90.85 78.1,90.59 78.61,90.59 U2.B16
  TOP w0.121: 77.83,90.85 76.89,90.85 76.62,91.13 74.8,91.13 73.32,92.62 73.06,92.62 v1(72.81,92.87) 72.37,93.32 71.99,93.32 71.54,93.76 R177.1
  BOTTOM w0.121: R553.1 71.03,96.03 71.72,95.34 71.72,93.96 v1(72.81,92.87)
AM335X_SPI0_SCLK: length 8
  TOP w0.102: 78.02,91 U2.A17
  TOP w0.121: 78.02,91 77.92,91.1 77,91.1 76.72,91.38 74.9,91.38 73.25,93.04 73.25,93.06 72.99,93.32 72.97,93.32 72.66,93.63 72.19,93.63 72.07,93.75 72.06,93.75 R201.1
AM335X_UART0_CTSN: length 13.6
  TOP w0.102: 81.91,92.9 81.91,92.31 U2.E18
  TOP w0.121: R364.2 79.29,103.16 79.29,102.4 81.94,99.74 81.94,97.7 81.73,97.48 81.73,94.64 81.91,94.45 81.91,92.9
AM335X_UART0_RTSN: length 10.8
  TOP w0.102: 81.65,92.9 81.65,92.57 81.06,91.99 81.06,91.35 81.4,91.01 U2.E17
  TOP w0.121: R216.1 80.17,99.23 81.34,99.23 81.69,98.87 81.69,97.87 81.66,97.83 81.66,97.83 81.48,97.65 81.48,97.48 81.48,94.53 81.65,94.36 81.65,92.9
AM335X_UART0_RXD: length 105
  TOP w0.102: v2(81,89.8) U2.E15
  TOP w0.121: v1(52.23,63.41) R249.2 ; v1(78.64,105.46) 78.02,104.84 77.81,104.84 77.4,104.44 77.4,103.47 78.4,102.48 78.4,100.2 78.15,99.95 78.15,99.52 78.57,99.1 79.54,99.1 80.17,98.46 R363.2 80.2,98.08 80.62,97.66 80.91,97.66 81.23,97.34 81.23,97.17 81.23,94.53 81.18,94.48 v1(81.18,94.04)
  LY3 w0.133: v1(51.14,107.12) 51.48,107.46 51.48,107.59 51.74,107.85 51.87,107.85 51.9,107.89 53.17,107.89 54.52,106.54 77.56,106.54 v1(78.64,105.46)
  BOTTOM w0.102: 80.58,90.97 80.58,90.24 81,89.83 v2(81,89.8)
  BOTTOM w0.121: v1(81.18,94.04) 81.14,94.04 80.54,93.45 80.54,91.01 80.58,90.97 ; v1(51.14,107.12) 47.43,107.12 44.84,104.53 44.84,103.38 44.81,103.35 44.81,98.78 44.64,98.61 44.64,94.02 45.12,93.53 45.12,80.81 44.35,80.04 43.04,78.72 43.04,71.95 48.02,66.97 51.22,66.97 52.23,65.95 v1(52.23,63.41)
AM335X_UART0_TXD: length 15.9
  TOP w0.102: v2(81,90.6) U2.E16
  TOP w0.121: v1(79,96.27) 78.7,96.57 73.31,96.57 R361.2
  BOTTOM w0.102: v2(81,90.6) 81,92.15 80.79,92.36 80.79,92.9
  BOTTOM w0.121: v1(79,96.27) 79.05,96.33 80.76,96.33 81.62,95.46 81.62,93.79 81.42,93.59 81.06,93.59 80.79,93.31 80.79,92.9
AM335X_UART1_CTSN: length 17.9
  TOP w0.102: U2.D18 80.74,91.94
  TOP w0.121: 80.74,91.94 80.74,94.51 80.98,94.75 80.98,96.53 80.79,96.73 v1(80.79,96.99) ; R357.1 75.86,103.54 76.56,103.54 v1(76.56,103.54)
  BOTTOM w0.121: v1(76.56,103.54) 78.12,103.54 79.46,102.2 79.46,101.15 78.93,100.62 78.9,100.62 79.45,100.08 79.45,96.83 79.71,96.57 80.37,96.57 80.78,96.99 v1(80.79,96.99)
AM335X_UART1_RTSN: length 17.7
  TOP w0.102: U2.D17 80.59,91 80.24,91.35 80.24,91.92
  TOP w0.121: v1(76.54,102.37) 76.75,102.17 76.75,101 R229.1 76.74,99.99 76.74,98.34 77.57,97.51 80.14,97.51 80.34,97.3 80.34,96.81 80.74,96.41 80.74,94.93 80.49,94.69 80.49,92.17 80.24,91.92
  BOTTOM w0.121: v1(76.54,102.37) 76.54,102.35 76.9,101.99 76.9,101.33 77.61,100.62 77.76,100.62
AM335X_UART1_RXD: length 15.5
  TOP w0.102: v2(80.2,90.6) U2.D16
  TOP w0.121: R356.1 73.19,99.23 74.34,99.23 74.59,99.48 75.48,99.48 76.36,98.59 76.36,98.37 77.47,97.26 79.01,97.26 79.88,96.39 v1(79.88,95.88)
  BOTTOM w0.102: v2(80.2,90.6) 80.2,90.97 80.29,91.06 80.29,93.51
  BOTTOM w0.121: v1(79.88,95.88) 80.29,95.47 80.29,93.51
AM335X_UART1_TXD: length 12.7
  TOP w0.102: v2(80.2,89.8) U2.D15
  TOP w0.121: R236.1 75.34,96.81 79.11,96.81 79.44,96.48 79.44,95.7 79.85,95.29 v1(79.85,95.16)
  BOTTOM w0.102: v2(80.2,89.8) 79.98,90.02 79.98,90.04 79.78,90.25 79.78,90.43
  BOTTOM w0.121: 79.78,90.43 79.79,90.44 79.79,90.84 79.99,91.04 79.99,91.06 80.05,91.12 80.05,94.49 79.85,94.68 v1(79.85,95.16)
AM335X_USB0_CE: length 14.1
  TOP w0.102: v2(87.4,89.8) U2.M15
  TOP w0.121: v1(93.67,99.26) 93.64,99.23 93.64,99.09 93.14,98.59 TP23.1
  LY3 w0.133: v1(93.67,99.26) 93.25,98.84 92.24,98.84 89.57,96.18 89.57,95.13 87.86,93.42 87.86,90.82 87.8,90.76 87.8,90.46 87.8,90.46 87.8,90.21 87.4,89.81 v2(87.4,89.8)
AM335X_USB0_DRVVBUS: length 106.2
  TOP w0.102: U2.F16 v2(81.8,90.6)
  TOP w0.121: v1(138.42,144.6) 137.87,145.15 U22.4
  LY3 w0.133: v1(86.4,133.83) 94.59,133.83 101.51,140.75 118.66,140.75 121.45,143.55 137.36,143.55 v1(138.42,144.6)
  LY4 w0.133: v1(86.4,133.83) 86.21,133.83 85.06,132.69 85.06,130.59 83.98,129.51 83.98,119.65 83.07,118.73 82.49,118.73 81.33,117.58 81.33,98.31 81.26,98.24 81.26,97.34 81.33,97.27 81.33,95.18 80.49,94.33 80.49,92.77 80.73,92.52 80.73,92.52 80.96,92.29 80.97,92.29 81.8,91.45 v2(81.8,90.6)
  BOTTOM w0.121: v1(138.42,144.6) 137.35,144.6 R383.1
AM335X_USB0_VBUS: length 14.8
  TOP w0.254: v2(89,89.8) U2.P15
  TOP w0.508: 96.3,97.88 R563.1
  LY3 w0.127: v2(89,89.8) 89.41,90.21 89.41,90.88 89.01,91.27
  LY3 w0.133: 89.01,91.27 88.6,90.86 88.6,90.2 v2(89,89.8)
  LY3 w0.508: v1(94.84,97.05) 94.39,97.5 92.47,97.5 91.99,97.01 91.99,96.13 90.64,94.78 90,94.78 89.01,93.79 89.01,91.27
AM335X_USB1_CE: length 6.2
  TOP w0.102: 88.6,92.9 U2.P18
  TOP w0.121: 88.6,92.9 88.6,93.55 89.56,94.52 90.45,94.52 91.35,95.41 TP36.1
AM335X_USB1_DRVVBUS: length 133.6
  TOP w0.102: U2.F15 v2(81.8,89.8)
  TOP w0.121: U29.4 v1(146.58,144.83)
  LY3 w0.133: v1(143.36,132.94) 142.53,133.77 142.53,139.48 138.85,143.17 121.7,143.17 118.91,140.37 101.76,140.37 94.65,133.26 86.21,133.26 v1(85.57,133.9)
  LY4 w0.133: v1(85.57,133.9) 83.54,131.86 83.54,121.57 82.49,120.53 82.49,119.49 80.56,117.55 80.56,105.07 79.98,104.5 79.98,98.78 80.34,98.43 80.34,94.88 79.98,94.53 79.98,92.9 81.41,91.48 81.41,90.77 81.4,90.76 81.4,90.2 v2(81.8,89.8)
  BOTTOM w0.121: R387.1 146.21,145.2 v1(146.58,144.83) 146.58,143.09 146.34,142.85 145.33,142.85 145.01,142.53 145.01,137.51 143.42,135.93 143.42,133.01 v1(143.36,132.94)
AM335X_USB1_VBUS: length 11.2
  TOP w0.254: U2.T18 v2(90.2,92.37)
  LY4 w0.508: v1(89.85,101.74) 90.66,100.93 90.66,96.48 91.27,95.87 91.27,93.13 90.51,92.37 v2(90.2,92.37)
AM335X_VDDA_ADC: length 42.7
  TOP w0.381: v2(80.2,83.4) U2.D8
  TOP w0.508: v1(59.54,81.68) 60.17,81.68 60.28,81.57 64.38,81.57 64.49,81.46 65.8,81.46 66.12,81.79 69.29,81.79 70.21,80.87 70.26,80.87 70.26,80.87 70.79,80.87 71.02,81.1 72.27,81.1 73.32,82.14 76.58,82.14 76.64,82.08 v1(76.82,82.08) ; v1(49.31,74.43) v1(59,74.43)
  BOTTOM w0.152: v1(76.82,82.08) 77.19,82.08 77.82,82.71 79.67,82.71 80.2,83.25 v2(80.2,83.4)
  BOTTOM w0.508: v1(59,74.43) 59.54,74.97 59.54,79.68 59.52,79.7 59.52,81.66 v1(59.54,81.68) ; 50.33,74.71 49.6,74.71 v1(49.31,74.43) R501.1
AM335X_VDDS: length 40.2
  TOP w0.305: v2(81,81.8) U2.E6
  TOP w0.381: U2.E14 v2(81,89) ; v2(88.2,81.8) U2.N6 ; v2(89,84.2) U2.P9 ; v2(82.6,84.2) U2.F9 ; v2(89,89) U2.P14 ; v2(85.8,88.2) U2.K13
  TOP w0.635: v1(99.99,111.54) 99.1,111.54 97.69,110.14 94.44,110.14 93.18,108.88 v1(88.21,108.88)
  LY4 w0.635: v1(88.21,108.88) 88.21,99.66 87.83,99.29 v1(87.83,98.59)
  BOTTOM w0.102: 81.42,90.21 81.42,89.68 81,89.26 v2(81,89) ; 81.42,90.21 82.08,90.21 82.21,90.33 82.21,91.1 C96.1 81.42,91.07 81.42,90.21
  BOTTOM w0.508: C48.1 92.45,90.52 v1(92.9,90.08) 92.77,89.95 92.71,89.95 92.43,89.68 C50.1
  BOTTOM w0.635: C249.1 99.99,110.43 v1(99.99,111.54) 100.37,111.92 100.37,112.56 C89.1 100.75,115.32 R498.1
AM335X_VDDS_DDR: length 65.6
  TOP w0.381: U2.F5 v2(81.8,81) U2.E5 ; U2.H5 v2(84.2,81) U2.J5 ; v2(82.6,81) U2.G5 ; U2.L5 v2(85.8,81) U2.K5
  TOP w0.635: v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13) 101.57,73.13 104.37,70.33 104.37,68.7 105.36,67.71 C233.1 108.24,67.71 110.9,65.06 115.6,65.06 116.29,65.75 116.29,68.85 115.7,69.44 R508.2
  LY3 w0.635: v1(97.62,73.13) v1(97.04,73.13) v1(96.43,73.13) 95.3,74.26 v1(86.14,74.26)
  LY4 w0.635: 92.34,82.38 92.65,82.08 93.54,82.08 94.02,81.6 94.02,80.56 94.53,80.05 94.53,77.76 96.43,75.86 v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13)
  BOTTOM w0.381: C78.1 85.86,80.94 v2(85.8,81) ; C80.1 95.61,73 96.31,73 v1(96.43,73.13) ; C82.1 v1(97.62,73.13) ; v2(81.8,81) 81.76,81.04 C77.1 ; v1(86.14,74.26) 85.69,73.8 C309.1 ; v2(84.2,81) 84.26,80.94 C79.1 ; C76.1 83.3,81.7 v2(82.6,81)
  BOTTOM w0.635: v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13)
AM335X_VDDSHV1: length 54.5
  TOP w0.381: U2.P7 v2(89,83.4) U2.P8
  LY3 w0.102: 91.74,82.52 91.43,82.21 89.45,82.21 89,82.65 v2(89,83.4) 89.26,83.4 89.64,83.02 89.65,83.02 89.69,82.98 91.29,82.98
  LY3 w0.508: v1(108.37,82.08) 107.1,83.35 103.54,83.35 v1(102.91,82.71) 101.38,82.71 100.62,81.95 100.62,80.81 v1(99.99,80.17) 99.35,79.54 98.34,79.54 97.45,80.43 97.45,81.32 96.56,82.21 92.06,82.21 91.29,82.98
  BOTTOM w0.381: C31.1 88.31,83.4 v2(89,83.4)
  BOTTOM w0.508: v1(108.37,82.08) 115.48,74.97 120.69,74.97 122.11,73.54 R493.1 ; C258.1 101.65,79.4 101.38,79.67 100.49,79.67 v1(99.99,80.17) ; C32.1 103.8,82.71 v1(102.91,82.71)
AM335X_VDDSHV2: length 39.4
  TOP w0.381: v2(89,86.6) U2.P11 88.6,86.14 88.72,86.02 88.72,85.58 88.6,85.46 U2.P10
  TOP w0.508: C259.1 97.89,86.7 v1(95.85,86.7) 95.85,87.59 C92.1
  LY3 w0.635: v2(89,86.6) 89.15,86.45 89.15,86.33 89.68,85.8 91.99,85.8 92.54,86.35 93,86.35 93.69,87.04 94.73,87.04 95.07,86.7 v1(95.85,86.7) 96.87,87.73 99.11,87.73 99.7,88.33 99.7,90.3 102.22,92.82 108.29,92.82 110.5,95.03 v1(115.42,95.03)
  BOTTOM w0.381: C90.1 89,85.95 v2(89,86.6)
  BOTTOM w0.635: v1(115.42,95.03) 114.43,95.03 R545.1
AM335X_VDDSHV3: length 100.9
  TOP w0.381: U2.P12 v2(89,87.4) ; v2(89,88.2) U2.P13
  TOP w0.635: R546.1 v1(135,140.59)
  LY3 w0.635: v1(108.85,95.01) 107.65,93.81 102.54,93.81 v1(102.31,93.59) 101.87,93.59 100.9,92.62 100.37,92.62 99.54,91.79 97.94,91.79 97.14,90.99 97.14,89.66 96.57,89.09 96.14,89.09 v1(95.99,88.94) 94.97,87.92 93.28,87.92 93.24,87.97 93.17,87.97 ; v1(135,140.59) 133.45,142.15 129.83,142.15 128.43,140.75 126.78,140.75 126.28,141.26 126.28,141.77 126.02,142.02 126.02,142.12 125.61,142.53 125.03,142.53 124.78,142.28 123.61,142.28 119.29,137.96 119.29,135.93 v1(110.65,135.93)
  LY4 w0.635: v1(108.85,95.01) 110.55,96.71 110.55,100.16 111.54,101.15 111.54,103.92 109.89,105.57 109.89,135.17 v1(110.65,135.93)
  BOTTOM w0.381: v2(89,87.4) v2(89,88.2) 88.28,88.2 C94.1
  BOTTOM w0.508: C93.1 97.19,89.29 96.84,88.94 95.99,88.94 v1(95.99,88.94) ; v1(102.31,93.59) 102.85,93.59 C273.1
AM335X_VDDSHV4: length 104.9
  TOP w0.381: U2.H14 v2(84.2,89) U2.J14
  TOP w0.635: v1(122.47,133.7) 130.47,133.7 131.1,133.07 v1(133.58,133.07)
  LY3 w0.635: v1(84.16,114.59) 84.38,114.81 84.9,114.81 84.93,114.78 116.24,114.78 v1(119.42,111.61)
  LY4 w0.635: v1(84.15,95.39) 84.15,95.34 84.39,95.1 85.01,95.1 86.14,93.97 86.14,92.32 84.92,91.1 84.92,89.39 84.53,89 v2(84.2,89)
  BOTTOM w0.635: C42.1 84.07,89.13 v2(84.2,89) ; v1(84.16,114.59) 83.17,113.6 83.17,98.82 83.58,98.41 83.58,97.86 83.92,97.51 84.01,97.51 C274.1 84.82,96.51 84.15,95.83 v1(84.15,95.39) 84.15,95.12 83.6,94.58 C43.1 ; R494.1 134.69,133.07 v1(133.58,133.07) ; v1(119.42,111.61) 119.73,111.92 119.73,129.64 122.47,132.37 v1(122.47,133.7)
AM335X_VDDSHV5: length 74.6
  TOP w0.381: U2.L14 v2(85.8,89) U2.K14
  TOP w0.635: v1(98.34,130.09) 96.43,130.09 96.04,130.47 91.33,130.47 v1(91.24,130.57)
  LY4 w0.102: v2(85.8,89) 86.71,89 86.98,89.27 86.98,90.76 86.97,90.77 86.97,91.48 ; v2(85.8,89) 85.8,89.03 85.42,89.41 85.42,90.82 85.74,91.13 86.18,91.13 86.18,89.38 v2(85.8,89)
  LY4 w0.508: v1(88.81,96.25) 88.81,95.16 88.68,95.03 88.68,93.19 86.97,91.48 86.52,91.48 86.18,91.13
  BOTTOM w0.635: v1(91.24,130.57) 91.24,130.48 90.92,130.16 90.92,120.78 91.95,119.75 91.95,114.9 90.59,113.54 90.59,108.39 91.79,107.19 91.79,104.42 90.42,103.05 C257.1 90.59,102.8 90.59,100.68 90.14,100.24 90.14,98.53 89.06,97.45 C45.1 89.06,96.51 v1(88.81,96.25) ; R495.1 99.35,141.26 98.72,140.63 98.72,132.9 98.65,132.84 98.65,130.4 v1(98.34,130.09) ; C46.1 85.94,89.14 v2(85.8,89)
AM335X_VDDSHV6: length 15.7
  TOP w0.381: U2.G14 v2(82.6,89) U2.F14 ; U2.E13 v2(81,88.2) ; U2.P5 v2(89,81) ; U2.P5 v2(88.2,81) U2.N5 ; U2.P5 v2(89,81.8) U2.P6 ; U2.E10 v2(81,85.8) U2.E11 v2(81,86.6) U2.E12
  TOP w0.635: v1(50.31,85.07) 50.33,85.05 C28.1
  BOTTOM w0.381: C47.1 79.03,91.73 v2(78.52,92.24) ; v1(69.76,83.1) 70.14,83.48 70.9,83.48
  BOTTOM w0.635: C29.1 93.69,79.29 93.31,79.29 93.1,79.51 v2(92.91,79.51) ; v2(92.37,81.37) 92.37,81.57 92.24,81.69 C25.1 ; C27.1 82.47,89.13 v2(82.6,89) ; R496.1 50.31,86.85 v1(50.31,85.07) 51.51,85.07 C247.1
AM335X_XDMA_EVENT_INTR0: length 16.1
  TOP w0.102: U2.A15 77.45,89.4 77.1,89.75
  TOP w0.121: v1(71.03,95.06) 70.27,95.82 69.15,95.82 68.99,95.98 68.62,95.98 68.49,95.86 TP31.1 67.09,95.03 R349.1 ; v1(73.92,91.08) 74.36,91.08 74.56,90.89 75.08,90.89 76.06,89.91 76.94,89.91 77.1,89.75
  BOTTOM w0.121: v1(73.92,91.08) 73.89,91.08 73.5,91.47 73.5,91.93 73.24,92.19 71.81,92.19 71.24,92.76 71.24,93.35 71.03,93.56 v1(71.03,95.06)
AM335X_XDMA_EVENT_INTR1: length 32.3
  TOP w0.102: v2(80.2,89) U2.D14
  TOP w0.121: R77.2 63.73,92.3 v1(63.66,92.3) 63.09,92.87 TP32.1
  LY3 w0.133: v1(63.54,95.8) 64.55,96.81 74.71,96.81 v1(75.98,98.08)
  BOTTOM w0.102: 77.51,92.9 77.51,91.1 77.89,90.72 77.89,90.21 78.14,89.95 78.9,89.95 79.16,90.21 79.51,90.21 79.52,90.22 79.78,89.96 79.78,89.58 80.2,89.16 v2(80.2,89)
  BOTTOM w0.121: v1(63.66,92.3) 63.54,92.43 v1(63.54,95.8) 63.66,95.92 R351.1 ; v1(75.98,98.08) 76.49,97.57 76.49,95.92 77.51,94.91 77.51,92.9
CAP_VBB_MPU: length 4.2
  TOP w0.102: v2(79.41,85.8) 79.41,85.79 U2.C10
  BOTTOM w0.102: 77.22,85.8 v2(79.41,85.8)
  BOTTOM w0.121: 77.22,85.8 77.09,85.8 76.62,86.27 C72.1
CAP_VDD_SRAM_CORE: length 12.6
  TOP w0.102: v2(80.2,85) U2.D9
  TOP w0.121: C60.1 70.01,86.66 71.58,86.66 72.02,87.1 74.55,87.1 74.74,86.91 75.6,86.91 76.59,85.92 v1(76.59,85.42)
  BOTTOM w0.102: v2(80.2,85) 79.94,85 79.56,85.38 78.74,85.38 78.56,85.2 77.73,85.2
  BOTTOM w0.121: v1(76.59,85.42) 77.52,85.42 77.73,85.2
CAP_VDD_SRAM_MPU: length 5.7
  TOP w0.102: v2(80.2,86.6) U2.D11
  BOTTOM w0.102: 77.63,87.42 78.26,86.79 80.01,86.79 v2(80.2,86.6)
  BOTTOM w0.121: 77.63,87.42 75.85,87.42 C71.1
COM_AUD_CLK: length 2.8
  TOP w0.121: v1(4.61,125.39) 4.86,125.64 J11.52
  BOTTOM w0.121: R338.2 5.12,124.88 v1(4.61,125.39)
COM_AUD_FSYNC: length 2.6
  TOP w0.121: J11.54 v1(4.61,126.28)
  BOTTOM w0.121: R339.2 5.37,126.28 v1(4.61,126.28)
COM_AUD_IN: length 2.6
  TOP w0.121: J11.56 4.74,126.91 v1(4.61,127.04)
  BOTTOM w0.121: v1(4.61,127.04) 5.5,127.04 R340.2
COM_AUD_OUT: length 2.8
  TOP w0.121: J11.58 4.86,127.55 v1(4.61,127.8)
  BOTTOM w0.121: v1(4.61,127.8) 5.12,127.8 R341.2
COM_BTRST: length 6.8
  TOP w0.121: v1(19.21,139.1) 17.44,140.88 J11.89
  BOTTOM w0.121: 20.1,139.1 v1(19.21,139.1)
COM_BTUARTCTS: length 2.8
  TOP w0.121: J11.70 4.86,134.53 v1(4.61,134.78)
  BOTTOM w0.121: v1(4.61,134.78) 5.63,134.78 R344.2
COM_BTUARTDEBUG: length 3
  TOP w0.121: 6.07,136.44 v1(4.61,136.44)
  BOTTOM w0.121: TP45.1 4.48,136.44 v1(4.61,136.44)
COM_BTUARTRTS: length 3
  TOP w0.121: J11.72 5.94,135.29 4.86,135.29 v1(4.61,135.55)
  BOTTOM w0.121: v1(4.61,135.55) 5.24,135.55 R345.2
COM_BTUARTRX: length 2.8
  TOP w0.121: v1(4.61,134.02) 4.74,133.9 6.07,133.9
  BOTTOM w0.121: R343.2 5.5,134.02 v1(4.61,134.02)
COM_BTUARTTX: length 2.9
  TOP w0.121: J11.66 4.74,133.26 v1(4.61,133.13)
  BOTTOM w0.121: R342.2 5.24,133.13 v1(4.61,133.13)
COM_GNSS_PPS_OUT: length 21.8
  TOP w0.121: v1(7.66,129.96) 8.32,129.96 8.92,130.56 16.45,130.56 19.35,127.67 19.35,126.92 19.89,126.38 U14.10 ; v1(7.72,126.15) 7.72,125.57 7.28,125.13 6.2,125.13 J11.50
  BOTTOM w0.121: v1(7.66,129.96) 8.1,129.52 8.1,126.53 v1(7.72,126.15)
COM_GNSS_TIME_STAMP: length 25.9
  TOP w0.121: U13.10 19.11,120.03 18.71,120.43 18.71,123.61 17.94,124.37 17.94,127.42 15.79,129.57 10.06,129.57 8.79,128.29 8.79,125.38 7.77,124.37 J11.48
COM_SDIO_CLK: length 6.2
  TOP w0.121: v1(7.66,115.23) 7.4,115.48 J11.20
  BOTTOM w0.121: R485.2 R334.1 7.66,113.32 v1(7.66,115.23)
COM_SDIO_CMD: length 5.1
  TOP w0.121: v1(7.66,116.37) 7.28,116.75 J11.24
  BOTTOM w0.121: v1(7.66,116.37) 7.15,115.86 7.15,115.52 6.64,115.02 R333.1 R486.2
COM_SDIO_D0: length 6.2
  TOP w0.121: J11.26 v1(7.66,117.39)
  BOTTOM w0.121: v1(7.66,117.39) 8.34,117.39 8.47,117.26 8.47,116.7 8.34,116.57 8.14,116.57 7.83,116.88 R332.1 R487.2
COM_SDIO_D1: length 5.3
  TOP w0.121: v1(8.42,118.02) J11.28
  BOTTOM w0.121: v1(8.42,118.02) 8.39,117.99 6.67,117.99 R331.1 R488.2
COM_SDIO_D2: length 7.1
  TOP w0.121: 6.07,118.66 v1(7.66,118.66)
  BOTTOM w0.121: R330.1 R489.2 7.23,119.72 7.23,119.47 7.36,119.35 8.2,119.35 8.31,119.46 8.6,119.46 8.72,119.33 8.72,118.81 8.6,118.68 7.68,118.68 v1(7.66,118.66)
COM_SDIO_D3: length 6.4
  TOP w0.121: v1(7.86,119.85) 7.3,119.29 J11.32
  BOTTOM w0.121: v1(7.86,119.85) 7.89,119.87 7.89,121.35 R490.2 R329.1
COM_SLOW_CLK: length 36.3
  TOP w0.121: v1(15.91,109.43) 15.51,109.43 15.18,109.77 J11.1 ; v1(15.91,137.96) 16.1,137.78 U15.12
  BOTTOM w0.121: v1(15.91,109.43) 17.24,110.77 17.24,136.52 16.35,137.41 16.33,137.41 16.22,137.52 16.22,137.65 v1(15.91,137.96)
COM_WL_IRQ: length 8.2
  TOP w0.121: v1(12.48,119.04) 11.21,120.31 7.64,120.31 7.36,120.03 6.16,120.03 6.07,119.94 J11.34
  BOTTOM w0.121: R337.2 v1(12.48,119.04)
COM_WL_RS232_RX: length 3.1
  TOP w0.121: 14.07,113.58 v1(12.23,113.58)
  BOTTOM w0.121: v1(12.23,113.58) TP43.1
COM_WL_RS232_TX: length 2.8
  TOP w0.121: J11.11 15.4,112.94 v1(15.66,112.69)
  BOTTOM w0.121: v1(15.66,112.69) 15.4,112.94 TP42.1
COM_WL_RST: length 3.1
  TOP w0.121: J11.4 4.48,110.4 v1(4.36,110.27)
  BOTTOM w0.121: v1(4.36,110.27) 4.61,110.02 R327.2
COM_WL_UART_DBG: length 2.5
  TOP w0.121: J11.15 v1(15.66,114.21)
  BOTTOM w0.121: v1(15.66,114.21) TP44.1
COMAUD_CLK: length 21.2
  TOP w0.121: v1(7.66,124.88) 8.54,125.76 8.54,128.55 9.8,129.82 16.15,129.82 18.33,127.64 18.33,125.13 19.03,124.43 U14.13
  BOTTOM w0.121: R338.1 v1(7.66,124.88)
COMAUD_FSYNC: length 26.3
  TOP w0.121: U13.11 18.49,119.38 17.31,120.56 17.31,127.7 15.69,129.32 10.32,129.32 9.03,128.03 9.03,125.01 v1(8.78,124.75)
  BOTTOM w0.121: R339.1 7.34,125.32 8.23,125.32 8.78,124.77 v1(8.78,124.75)
COMAUD_IN: length 19
  TOP w0.121: v1(7.66,127.04) 8.29,127.67 8.29,128.82 9.54,130.06 16.25,130.06 18.71,127.61 18.71,125.77 19.4,125.08 U14.12
  BOTTOM w0.121: R340.1 7.53,127.16 v1(7.66,127.04)
COMAUD_OUT: length 17.4
  TOP w0.121: U14.11 19.51,125.73 18.96,126.28 18.96,127.7 16.35,130.31 9.03,130.31 v1(7.66,128.94)
  BOTTOM w0.121: v1(7.66,128.94) 7.02,128.31 R341.1
COMBTRST: length 2.2
  TOP w0.121: U15.10 21.65,139.08 v1(21.88,139.1)
  BOTTOM w0.121: R353.2 v1(21.88,139.1)
COMBTUARTCTS: length 16.4
  TOP w0.121: U16.12 19.16,131.43 18.89,131.69 8.56,131.69 7.97,132.28 7.97,134.47 v1(7.53,134.91)
  BOTTOM w0.121: R344.1 v1(7.53,134.91)
COMBTUARTRTS: length 16.6
  TOP w0.121: U16.10 16.65,132.73 16.11,132.18 11.4,132.18 10.96,132.63 10.96,134.4 9.31,136.05 v1(7.53,136.05)
  BOTTOM w0.121: R345.1 v1(7.53,136.05)
COMBTUARTRX: length 15.8
  TOP w0.121: v1(7.53,133.77) 7.53,132.37 8.46,131.44 18.42,131.44 19.09,130.78 U16.13
  BOTTOM w0.121: R343.1 v1(7.53,133.77)
COMBTUARTTX: length 14.1
  TOP w0.121: v1(8.41,132.63) 9.1,131.94 16.62,131.94 16.76,132.08 U16.11
  BOTTOM w0.121: R342.1 v1(8.41,132.63)
COMWL_IRQ: length 6.7
  TOP w0.121: U13.13 18.73,118.08 17.24,119.57 v1(15.91,119.57)
  BOTTOM w0.121: v1(15.91,119.57) 15.38,119.04 R337.1
COMWL_RST: length 37.1
  TOP w0.121: v1(16.06,135.98) 17.21,137.13 U15.13
  BOTTOM w0.121: R327.1 v1(7.66,110.4) 11.21,113.96 11.21,134.66 12.53,135.98 v1(16.06,135.98)
DDR_A0: length 61.3
  TOP w0.102: U2.F3 v2(81.8,79.4)
  TOP w0.121: R604.2 93.28,66.2 93.39,66.1 93.39,65.63 93.29,65.53 v1(92.85,65.53) ; v1(75.98,61.44) U34.K3 ; v1(90.58,61.44) U33.K3
  LY4 w0.076: v1(75.98,61.44) 76.41,61.87 76.41,62.39 76.82,62.8 77.18,62.8 77.51,63.13 79.06,63.13 79.92,63.99 80.3,63.99 80.4,63.89 80.4,63.59 80.53,63.46 84.26,63.46 ; 91.78,64.46 91.78,63.67 91.55,63.44 91.22,63.44 90.99,63.21 90.99,62.7 90.58,62.29 v1(90.58,61.44) 90.22,61.08 87.53,61.08 87.4,61.21 87.29,61.21
  LY4 w0.133: 91.78,64.46 92,64.68 92,64.74 92.47,65.21 92.53,65.21 v1(92.85,65.53) ; 87.29,61.21 87.06,61.21 86.43,61.84 85.79,61.84 85.66,61.97 85.66,62.88 84.75,63.79 84.59,63.79 84.26,63.46
  BOTTOM w0.121: v1(75.98,61.44) 76.18,61.64 76.27,61.64 76.47,61.84 78.53,61.84 78.54,61.84 78.54,61.84 78.77,62.07 78.77,62.69 78.8,62.72 78.8,63.82 78.67,63.94 77.86,63.94 77.74,64.07 77.74,64.71 77.86,64.83 78.62,64.83 78.75,64.96 78.75,65.19 78.62,65.32 77.86,65.32 77.74,65.44 77.74,67.14 77.86,67.27 78.04,67.27 78.17,67.14 78.17,66.53 78.29,66.41 78.45,66.41 78.57,66.53 78.57,67.8 78.45,67.93 76.9,67.93 76.77,67.8 76.77,67.12 76.64,66.99 75.7,66.99 75.58,67.12 75.58,67.7 75.7,67.83 76.02,67.83 76.3,68.11 76.3,68.3 76.43,68.43 78.17,68.43 78.29,68.56 78.29,69.38 78.42,69.51 79.5,69.51 79.63,69.63 79.63,69.74 79.64,69.76 79.64,71.39 79.64,73.98 79.45,74.17 79.45,76.75 80.35,77.65 80.36,77.65 81.8,79.09 v2(81.8,79.4)
DDR_A1: length 60.9
  TOP w0.121: v1(89.78,59.04) U33.L7 ; U2.H1 83.8,76.83 83.8,75.02 84.14,74.69 84.14,74.19 83.27,73.33 v1(83.27,72.88) ; v1(75.18,59.04) U34.L7
  LY4 w0.076: 87.31,58.83 87.32,58.81 87.54,58.81 87.69,58.67 89.41,58.67 v1(89.78,59.04)
  LY4 w0.133: 87.31,58.83 85.89,58.83 85.46,59.25 84.64,59.25 84.63,59.25 83.04,59.25 82.92,59.37 82.92,60.46 82.79,60.58 77.48,60.58 77.35,60.46 77.35,60.03 77.13,59.81 74.92,59.81 74.79,59.68 74.79,59.42 v1(75.18,59.04) ; v1(83.27,72.88) 80.78,72.88 v1(77.28,69.38)
  BOTTOM w0.121: v1(89.78,59.04) 89.38,58.63 87.62,58.63 86.52,57.54 R605.2
  BOTTOM w0.127: v1(77.28,69.38) 77.08,69.58 75.5,69.58 74.9,68.98 74.9,68.98 74.48,68.55 74.48,67.38 74.15,67.05 72.81,67.05 72.46,66.69 72.46,65.01 72.36,64.91 71.33,64.91 71.21,65.04 71.21,65.25 71.08,65.38 70.16,65.38 69.75,64.97 69.75,63.4 70.85,62.29 72.33,62.29 72.45,62.17 72.45,60.97 72.58,60.84 74.08,60.84 75.18,59.75 v1(75.18,59.04)
DDR_A2: length 61
  TOP w0.102: U2.E4 v2(81,80.2)
  TOP w0.121: v1(90.89,65.34) 91.2,65.65 91.2,65.84 R606.2 ; v1(75.18,61.44) U34.L3 ; v1(89.78,62.24) U33.L3
  LY4 w0.076: 87.39,61.73 87.39,61.73 87.72,61.41 88.96,61.41 v1(89.78,62.24) 90.15,62.6 90.15,64.1 90.3,64.25 ; v1(75.18,61.44) 75.61,61.87 75.61,62.39 76.33,63.11 77.05,63.11 77.41,63.47 78.73,63.47 79.72,64.46
  LY4 w0.127: 79.72,64.46 79.78,64.46
  LY4 w0.133: 79.78,64.46 79.79,64.46 79.84,64.51 84.84,64.51 86.28,63.07 86.28,62.76 87.31,61.73 87.39,61.73 ; 90.3,64.25 90.3,66.25 90.43,66.38 90.77,66.38 90.89,66.25 v1(90.89,65.34)
  BOTTOM w0.121: v2(81,80.2) 81.39,79.81 81.39,79.24 81.34,79.19 81.34,79.06 79.2,76.91 79.2,76.47 79.07,76.34 78.68,76.34 78.55,76.21 78.55,75.93 78.68,75.81 79.07,75.81 79.2,75.68 79.2,75.48 79.07,75.35 78.68,75.35 78.55,75.22 78.55,74.99 78.68,74.87 79.03,74.87 79.16,74.74 79.16,74.51 79.03,74.38 78.68,74.38 78.55,74.26 78.55,74.08 78.88,73.75 79.26,73.75 79.39,73.62 79.39,71.16 79.26,71.03 78.53,71.03 78.19,70.7 78.19,70.47 78.32,70.34 79.25,70.34 79.37,70.22 79.37,69.94 79.25,69.81 78.17,69.81 78.04,69.68 78.04,68.81 77.91,68.68 76.8,68.68 76.67,68.81 76.67,68.95 76.54,69.07 76.16,69.07 76.05,68.96 76.05,68.21 75.92,68.08 75.45,68.08 75.32,67.96 75.32,66.81 75.45,66.69 77.35,66.69 77.48,66.56 77.48,66.23 77.35,66.1 76.47,66.1 76.34,65.98 76.34,65.7 76.49,65.54 77.28,65.54 77.41,65.42 77.41,65.27 77.28,65.14 77.02,65.14 76.9,65.01 76.9,64.93 76.9,64.53 76.37,64 76.37,62.4 76.37,62.4 76.37,62.07 76.14,61.84 75.83,61.84 75.42,61.44 v1(75.18,61.44)
DDR_A3: length 61.9
  TOP w0.102: v2(79.4,79.4) U2.C3
  TOP w0.121: v1(91.86,65.34) 91.86,64.88 91.99,64.76 92.21,64.76 92.34,64.88 92.34,65.72 R607.2 ; U33.K2 v1(90.58,63.04) ; v1(75.98,62.24) U34.K2 75.91,63.1 75.91,63.57 75.65,63.83 75.65,64.58 75.14,65.09 74.1,65.09 72.02,67.17 72.02,69.02 72.8,69.8 73.11,69.8 v1(73.42,70.12)
  LY4 w0.076: 79.87,64.25 78.94,63.31 77.47,63.31 77.11,62.95 76.69,62.95 v1(75.98,62.24) ; 87.29,61.47 87.35,61.47 87.6,61.23 89.3,61.23 90.31,62.24 90.31,62.76 v1(90.58,63.04) 90.95,63.4 90.95,64.05
  LY4 w0.133: 90.95,64.05 90.95,64.77 91.08,64.89 91.34,65.15 91.34,65.87 91.47,66 91.73,66 91.86,65.87 v1(91.86,65.34) ; 87.29,61.47 87.17,61.47 86.54,62.1 86.09,62.1 85.97,62.23 85.97,62.95 84.67,64.25 79.87,64.25
  BOTTOM w0.121: v1(73.42,70.12) 73.42,71.54 73.54,71.67 75.25,71.67 75.37,71.8 75.37,72.05 75.25,72.18 73.57,72.18 73.44,72.3 73.44,72.56 73.57,72.68 75.25,72.68 75.37,72.81 75.37,73.07 75.25,73.19 73.54,73.19 73.42,73.32 73.42,73.57 73.54,73.7 75.25,73.7 75.37,73.83 75.37,74.08 75.25,74.21 73.54,74.21 73.42,74.34 73.42,75.2 73.7,75.47 73.88,75.47 74.13,75.22 74.31,75.22 74.49,75.4 74.49,75.58 74.24,75.83 74.24,76.01 76.54,78.32 76.87,78.32 77.95,79.4 v2(79.4,79.4)
DDR_A4: length 60.9
  TOP w0.121: v1(71.73,65.77) 71.28,65.77 71.15,65.9 71.15,68.79 72.68,70.32 72.68,70.83 72.94,71.08 74.31,71.08 74.56,71.33 74.56,73.76 74.69,73.88 75.6,73.88 75.73,73.76 75.73,73.14 75.86,73.01 76.62,73.01 76.75,73.14 76.75,74.15 77.53,74.94 78.3,74.94 78.57,75.22 78.57,76.35 80.14,77.92 80.14,78.66 U2.C2 ; U34.L8 v1(75.18,57.44) ; U33.L8 v1(89.78,57.44)
  LY4 w0.133: v1(89.78,57.44) 89.39,57.04 89.39,56.47 89.39,56.47 89.39,55.73 89.14,55.49 82.79,55.49 82.41,55.87 80.28,55.87 79.62,56.53 79.62,57.57 79.34,57.85 75.59,57.85 v1(75.18,57.44)
  BOTTOM w0.076: v1(89.78,57.44) 89.78,57.87 89.66,58 89.48,58 89.35,57.87 89.35,56.48 89.11,56.24 89.11,55.54
  BOTTOM w0.121: v1(75.18,57.44) 74.61,58 74.61,58.72 74.77,58.87 74.77,59.75 73.95,60.57 72.22,60.57 69.5,63.29 69.5,65.07 70.05,65.63 70.99,65.63 71.13,65.77 v1(71.73,65.77) ; 89.11,55.54 89.38,55.27 90.93,55.27 91.32,54.88 91.5,54.88 R608.2
DDR_A5: length 61.1
  TOP w0.121: U34.L2 v1(75.18,62.24) ; v1(89.6,65.37) 89.91,65.05 90.07,65.05 90.26,65.24 90.26,66.08 90.13,66.2 R609.2 ; U33.L2 v1(89.78,63.04)
  TOP w0.127: v1(70.45,64.68) 68.46,66.66 68.46,71.94 68.59,72.07 68.92,72.07 69.05,71.94 69.05,70.73 69.18,70.6 69.58,70.6 69.71,70.73 69.71,71.97 69.84,72.1 72.05,72.1 72.3,72.35 72.3,74.21 72.5,74.41 73.59,74.41 73.71,74.54 73.71,74.84 73.59,74.97 72.45,74.97 72.33,75.09 72.33,75.4 72.45,75.53 73.59,75.53 73.71,75.65 73.71,76.59 73.92,76.8 74.32,76.8 74.78,77.25 78.27,77.25 78.67,77.65 78.69,77.65 79,77.97 U2.B1
  LY4 w0.076: v1(75.18,62.24) 76.2,63.26 76.99,63.26 77.37,63.64 78.61,63.64 79.65,64.67 ; 87.29,62.13 87.85,61.56 88.83,61.56 89.39,62.13 89.39,62.65 v1(89.78,63.04) 89.41,63.4 89.41,63.96 89.29,64.09 89.25,64.09 88.99,64.35
  LY4 w0.133: 87.29,62.13 86.61,62.8 86.61,63.14 84.99,64.77 79.74,64.77 79.65,64.67 ; 88.99,64.35 88.99,65.9 89.11,66.03 89.47,66.03 89.6,65.9 v1(89.6,65.37)
  BOTTOM w0.121: v1(75.18,62.24) 75.18,63 74.92,63.26 73.42,63.26 73.16,63.51 73.16,63.95 73.04,64.07 71.06,64.07 v1(70.45,64.68)
DDR_A6: length 61.1
  TOP w0.102: U2.D5 v2(80.2,81)
  TOP w0.121: v1(74.38,57.44) U34.M8 ; v1(88.98,57.44) U33.M8
  LY4 w0.133: v1(88.98,57.44) 88.58,57.03 88.58,55.92 88.42,55.76 82.94,55.76 82.54,56.17 80.4,56.17 79.89,56.68 79.89,57.83 79.6,58.12 74.88,58.12 74.66,57.89 74.66,57.71 v1(74.38,57.44)
  BOTTOM w0.076: v1(88.98,57.44) 88.98,57.88 88.86,58 88.68,58 88.56,57.88 88.56,57.24 88.73,57.06 88.73,56.96 88.56,56.78 88.56,56.43 88.71,56.27 88.71,56.02 88.45,55.76 88.45,55.61 88.53,55.54
  BOTTOM w0.102: 80.61,80.5 80.61,79.95
  BOTTOM w0.121: 80.61,79.95 80.61,79.21 80.43,79.03 80.43,78.93 78.02,76.52 78.02,73.85 78.88,72.98 78.88,72.2 76.61,69.93 75.46,69.93 73.47,67.94 71.68,67.94 70.65,66.92 70.42,66.92 68.9,65.39 68.9,63.43 68.91,63.42 68.91,63.05 68.9,63.04 68.9,62.06 71.34,59.62 73.64,59.62 73.97,59.28 73.97,57.84 v1(74.38,57.44) ; R610.2 90.72,54.95 90.64,55.02 90.41,55.02 90.21,54.83 90.11,54.83 89.91,55.02 89.27,55.02 88.91,55.38 ; v2(80.2,81) 80.61,80.59 80.61,80.5
  BOTTOM w0.127: 88.91,55.38 88.68,55.38 88.53,55.54
DDR_A7: length 61.1
  TOP w0.121: v1(74.38,62.24) U34.M2 ; v1(81.44,68.46) 81.44,71 81.32,71.13 78.02,71.13 77.89,71.26 77.89,71.84 78.02,71.97 79.41,71.97 81.44,74 81.44,74.97 81.85,75.37 81.85,77.76 81.78,77.83 81.78,78.63 81.41,79 U2.E2 ; v1(88.98,63.04) U33.M2
  LY4 w0.076: 87.31,63.24 87.64,62.91 87.64,62.41 87.81,62.24 87.81,62.08 88.03,61.87 88.33,61.87 88.55,62.08 88.55,62.6 v1(88.98,63.04) ; 72.81,61.25 73.21,60.84 73.85,60.84 73.95,60.94 73.95,61.52 74.12,61.7 74.12,61.97 v1(74.38,62.24) 76.03,63.89 76.26,63.89 76.57,64.2 77.25,64.2
  LY4 w0.127: 74.56,65.8 74.56,66.84 74.88,67.16 76.38,67.16 77.02,67.8 78.09,67.8 79.3,69.01 81.35,69.01 81.44,68.91 v1(81.44,68.46)
  LY4 w0.133: 74.56,65.8 74.07,65.32 72.99,65.32 72.66,64.98 72.66,61.4 72.81,61.25 ; 87.31,63.24 85.24,65.3 79.5,65.3 78.4,64.2 77.25,64.2
  BOTTOM w0.076: v1(88.98,63.04) 89.35,62.67 89.35,62.08 89.57,61.86 90.09,61.86 90.21,61.99 90.21,64.15 90.49,64.43 90.49,64.68
  BOTTOM w0.121: 90.49,64.68 90.49,65.03 90.18,65.33 90.18,65.85 R611.2
DDR_A8: length 59.1
  TOP w0.102: v1(80.2,80.2) U2.D4
  TOP w0.121: v1(73.58,57.44) U34.N8 ; U33.N8 88.58,58.1 88.51,58.18 87.74,58.18 87.62,58.05 87.62,57.56 87.74,57.44 v1(88.18,57.44)
  LY4 w0.133: v1(88.18,57.44) 86.94,56.2 83.06,56.2 83.02,56.24 83.01,56.24 82.78,56.47 82.78,56.48 82.77,56.48 82.77,56.8 82.76,56.81 82.76,56.82 82.54,57.04 81.06,57.04 79.72,58.38 74.51,58.38 73.86,57.73 73.86,57.71 v1(73.58,57.44)
  BOTTOM w0.076: v1(88.18,57.44) 88.18,57.07 88.12,57 87.95,57 87.82,56.88 87.82,56.79 87.81,56.79 87.81,56.37 87.94,56.25 88.15,56.25 88.28,56.12 88.28,55.94 88.15,55.82 88.11,55.82 87.98,55.69 87.98,55.6
  BOTTOM w0.121: v1(80.2,80.2) 79.81,79.81 79.81,79.2 79.62,79.01 78.96,79.01 77.38,77.43 77.38,75.17 75.63,73.42 75.63,71.69 75.35,71.41 74.34,71.41 73.87,70.95 73.87,69.42 73.16,68.71 70.92,68.71 70.09,67.88 69.66,67.88 67.58,65.8 67.58,61.35 71.49,57.44 v1(73.58,57.44) ; 88.05,55.54 88.48,55.1 88.81,55.1 89.19,54.73 89.19,54.7 89.37,54.52 R612.2
  BOTTOM w0.127: 87.98,55.6 88.05,55.54
DDR_A9: length 60.9
  TOP w0.121: U34.M3 v1(74.38,61.44) 73.86,60.92 73.42,60.92 72.81,61.53 72.81,63.03 68.9,66.94 68.9,70.12 69.02,70.24 69.39,70.24 69.52,70.12 69.52,68.08 69.65,67.96 70.29,67.96 70.42,68.08 70.42,70.45 70.54,70.57 70.94,70.57 70.95,70.57 71.13,70.57 71.26,70.7 71.26,71.46 71.39,71.59 72.68,71.59 72.94,71.84 72.94,73.65 73.19,73.9 73.8,73.9 74.22,74.32 74.22,75.41 74.41,75.6 74.68,75.6 74.87,75.41 74.87,74.54 74.99,74.41 76.59,74.41 77.79,75.6 77.79,75.92 79.8,77.93 U2.C1 ; R613.2 88.45,66.56 87.95,66.56 87.82,66.43 87.82,65.91 87.95,65.78 88.14,65.78 v1(88.45,65.47) ; v1(88.98,62.24) U33.M3
  LY4 w0.076: v1(74.38,61.44) 74.76,61.82 74.76,62.39 75.81,63.44 76.9,63.44 76.93,63.47 76.93,63.47 77.25,63.79 78.4,63.79 79.15,64.55 ; 87.39,62.39 87.55,62.23 87.55,62.13 87.97,61.71 88.46,61.71 v1(88.98,62.24) 88.98,62.51 89.35,62.88 89.35,63.23 89.11,63.47 88.7,63.47 88.58,63.59
  LY4 w0.133: 79.15,64.55 79.63,65.03 85.1,65.03 87.39,62.74 87.39,62.39 ; 88.58,63.59 88.58,63.96 88.58,63.96 88.58,64 88.53,64.05 88.53,64.45 88.57,64.49 88.57,64.87 88.45,64.98 v1(88.45,65.47)
DDR_A10: length 61
  TOP w0.102: U2.F4 v2(81.8,80.2)
  TOP w0.121: U33.H7 v1(92.98,59.04) ; U34.H7 v1(78.38,59.04)
  LY4 w0.076: 87.29,58 87.54,58 87.69,58.15 93.15,58.15 93.24,58.24
  LY4 w0.133: v1(78.38,59.04) 78.38,59.74 78.52,59.89 81.77,59.89 82.03,59.63 82.03,58.74 82.28,58.48 84.63,58.48 84.64,58.47 85.11,58.47 85.58,58 87.29,58 ; v1(92.98,59.04) 93.24,58.77 93.24,58.24
  BOTTOM w0.076: 93.68,55.54 93.66,55.56 93.66,56.71 93.3,57.07 92.83,57.07 92.61,57.28 92.61,58.67 v1(92.98,59.04)
  BOTTOM w0.121: v1(78.38,59.04) 78.75,59.4 79.01,59.4 79.89,60.29 80.48,60.29 83.35,63.16 84.24,63.16 84.54,63.46 84.54,65.75 84.8,66 86.09,66 86.22,66.13 86.22,67.3 86.09,67.42 84.14,67.42 84.01,67.3 84.01,67.18 83.88,67.05 83,67.05 82.77,67.28 82.4,67.28 82.31,67.19 80.2,67.19 79.69,67.7 79.69,69.18 79.88,69.37 79.88,69.64 80.05,69.8 80.05,74.3 79.92,74.42 79.83,74.42 79.7,74.55 79.7,76.65 80.46,77.4 80.51,77.4 82.21,79.09 82.21,79.79 81.8,80.2 v2(81.8,80.2) ; R614.2 95.26,54.88 95.26,55.18 95.14,55.31 93.91,55.31 93.68,55.54

# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_2a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PMIC_I2C_SCL: length 149.2
  TOP w0.121: v1(141.54,99.02) 141.36,98.84 138.89,98.84 137.97,97.91 137.97,96.43 137.08,95.54 132.37,95.54 131.54,94.71 131.54,94.63 131.23,94.31 R55.1 ; v1(121.58,58.2) 122.08,58.2 122.79,58.9 129.01,58.9 129.08,58.84 131.8,58.84 132.87,57.77 140.07,57.77 v1(140.58,58.28)
  TOP w0.203: U4.9 90.45,29.95 90.84,29.55 v1(90.84,28.99)
  LY3 w0.133: v1(85.36,26.52) 88.81,26.52 90.84,28.55 v1(90.84,28.99)
  BOTTOM w0.121: R551.1 84.26,25.06 85.36,26.15 v1(85.36,26.52) ; v1(140.58,58.28) 140.58,58.71 140.6,58.74 140.6,65.94 141.38,66.72 141.38,71.57 141.9,72.08 141.9,75.38 143.29,76.78 143.29,82.72 143.1,82.91 143.1,87.63 142.29,88.44 142.29,93.49 141.82,93.95 141.82,94.3 141.81,94.31 141.81,98.48 141.54,98.75 v1(141.54,99.02) ; v1(121.58,58.2) 121.07,57.7 121.07,46.84 112.37,38.14 112.37,28.68 109.13,25.44 109.13,23.57 106.77,21.2 106.67,21.2 106.65,21.18 101.38,21.18 95.41,27.15 93.05,27.15 91.21,28.99 v1(90.84,28.99)
PMIC_I2C_SDA: length 115.2
  TOP w0.121: U4.8 90.05,29.66 v1(90.21,29.5) ; v1(57.7,31.03) 74.48,31.03 79.31,26.2 81.05,26.2 81.56,26.71 84.25,26.71 v1(84.44,26.52) ; R56.1 68.36,92.75 67.85,93.26 66.41,93.26 66.24,93.43 66.07,93.43 65.55,93.95 64.76,93.95 63.92,94.79 61.04,94.79 60.68,94.43 v1(60.68,93.76)
  LY3 w0.133: v1(90.21,29.5) 87.92,27.22 85.14,27.22 v1(84.44,26.52)
  BOTTOM w0.121: v1(84.44,26.52) 84.12,26.2 R550.1 ; v1(60.68,93.76) 60.05,93.13 60.05,91.96 59.96,91.87 59.96,89.36 61.1,88.22 61.1,87.21 61.82,86.49 61.82,83.58 62.45,82.95 62.45,81.54 62.48,81.51 62.48,81.5 62.53,81.44 62.53,81.4 62.87,81.07 62.87,72.77 62.21,72.11 59.41,69.31 59.41,58.65 57.63,56.87 57.63,35.8 57.44,35.6 57.44,34.58 57.7,34.33 v1(57.7,31.03)
PMIC_INTN: length 132.9
  TOP w0.121: U4.45 v1(85.52,32.69) ; v1(60.49,107.25) 60.96,107.72 66.04,107.72 66.71,108.39 78.52,108.39 79.76,107.15 79.76,106.26 80.43,105.59 80.43,103.29 79.79,102.65 R66.1 ; v1(55.33,42.53) 55.56,42.3 58.81,42.3 59.74,41.38 71.4,41.38 71.98,40.8 79.03,40.8 v1(79.67,40.17)
  BOTTOM w0.121: v1(55.33,42.53) 56.15,43.35 56.15,57.67 57.17,58.69 57.17,68.57 57.17,69.65 60.47,72.96 60.47,80.72 60.47,82.13 59.84,82.76 59.84,85.58 59.1,86.32 59.1,87.41 58.81,87.7 58.56,87.95 58.27,88.24 57.98,88.53 57.98,88.54 57.98,92.69 58.07,92.78 58.07,93.05 58.07,101.73 59.12,102.78 59.12,105.88 v1(60.49,107.25) ; v1(79.67,40.17) 80.96,38.87 82.55,38.87 85.79,35.64 85.79,33.49 85.52,33.23 v1(85.52,32.69)
PMIC_PWR_EN: length 359.7
  TOP w0.102: v2(79.4,81.8) U2.C6
  TOP w0.121: v1(134.17,39.79) 131.99,39.79 129.7,42.07 v1(129.7,42.71) 129.7,44.3 128.24,45.76 109.71,45.76 108.64,46.83 106.17,46.83 105.6,47.41 89.11,47.41 88.48,46.77 80.5,46.77 v1(79.87,47.41) 73.7,47.41 72.83,48.28 72.59,48.28 71.82,49.06 70.14,49.06 69.51,49.69 66.84,49.69 66.08,48.93 65.12,48.93 64.93,48.74 v1(64.43,48.74) 45.82,48.74 40.49,43.41 19.6,43.41 16.67,46.33 16.67,50.39 v1(15.91,51.15) ; v1(144.41,93.51) 143.57,94.35 143.32,94.35 142.65,95.02 140.04,95.02 139.19,94.17 137.6,94.17 v1(136.94,93.51) ; R358.2 14.52,99.22 14.9,98.84 v1(14.9,97.95)
  BOTTOM w0.102: 77.1,80.69 77.96,81.55 79.15,81.55 v2(79.4,81.8)
  BOTTOM w0.121: v1(144.41,93.51) 144.41,88.94 145.45,87.9 145.45,82.97 144.8,82.31 144.8,76.16 144.21,75.57 144.21,59.11 134.96,49.86 134.96,46.86 134.22,46.11 134.22,41.24 134.17,41.19 v1(134.17,39.79) ; v1(64.43,48.74) 65.38,49.7 65.38,56.87 65.06,57.19 65.06,58.2 65.44,58.58 66.2,58.58 66.71,59.09 66.71,60.55 65.7,61.57 65.7,63.41 66.65,64.36 66.65,67.47 66.97,67.79 66.97,69.89 69.38,72.3 69.38,79.29 70.24,80.15 72.25,80.15 72.3,80.1 73.91,80.1 73.96,80.15 76.06,80.15 76.25,80.34 76.73,80.34 77.08,80.69 77.1,80.69 ; v1(136.94,93.51) 135.91,92.47 133.83,92.47 133.76,92.55 132.76,92.55 132.69,92.47 131.76,92.47 R178.1 ; R478.2 144.31,20.74 142.66,19.09 138.72,19.09 138.59,18.96 137.83,18.96 137.45,19.34 137.45,20.87 135.93,22.39 135.93,24.07 130.09,29.91 130.09,41.31 129.7,41.69 v1(129.7,42.71) ; v1(79.87,47.41) 78.52,46.06 78.52,41.94 81.18,39.28 82.59,39.28 86.04,35.83 86.04,32.07 R556.2 ; v1(15.91,51.15) 15.91,69.4 14.9,70.41 v1(14.9,97.95)
PMIC_PWRHOLD: length 3.6
  TOP w0.121: U4.1 87.15,30.72 86.91,30.47 86.91,30.26 86.57,29.93 v1(86.52,29.93)
  BOTTOM w0.121: v1(86.52,29.93) 86.48,29.93 86.02,30.4 R556.1
PMIC_RESETOUTN: length 100.3
  TOP w0.121: U4.40 85.65,34.69 85.57,34.77 84.94,34.77 v1(84.49,34.33) 84.34,34.48 84.34,37.78 83.86,38.26 80.27,38.26 78.37,40.17 71.69,40.17 71,40.85 56.83,40.85 v1(56.5,40.52) ; R1.2 60.05,100.55 60.05,100.16 60.06,100.15 60.06,99.81 v1(59.27,99.02)
  BOTTOM w0.121: v1(59.27,99.02) 59.27,98.06 59.06,97.84 59.06,93.46 59.06,92.37 58.97,92.28 58.97,89.77 58.97,88.94 60.11,87.8 60.11,86.71 60.52,86.3 60.83,85.99 60.83,83.17 61.46,82.54 61.46,72.42 58.21,69.16 58.21,58.21 57.14,57.14 57.14,41.16 v1(56.5,40.52) ; R65.2 v1(84.49,34.33)
PMIC_SLEEP: length 126
  TOP w0.121: v1(55.94,41.39) 56.01,41.46 58.46,41.46 58.82,41.1 71.33,41.1 71.9,40.54 78.35,40.54 80.37,38.51 83.99,38.51 84.75,37.76 84.75,36.87 85.72,35.89 U4.37 ; v1(78.64,104.75) 78.28,104.75 78.12,104.59 77.91,104.59 77.65,104.33 77.65,103.6 78.65,102.6 R62.1
  LY3 w0.133: v1(60.01,103.87) 60.01,104.35 61.37,105.72 66.38,105.72 66.59,105.51 75.41,105.51 75.5,105.6 76.82,105.6 77.67,104.75 v1(78.64,104.75)
  BOTTOM w0.121: v1(55.94,41.39) 56.64,42.1 56.64,57.41 57.66,58.43 57.66,69.45 60.68,72.46 60.97,72.75 60.97,82.33 60.33,82.97 60.33,85.79 60.03,86.09 59.6,86.53 59.6,87.62 58.76,88.45 58.47,88.74 58.47,92.49 58.56,92.57 58.56,93.25 58.56,101.34 60.01,102.78 v1(60.01,103.87)
PMICSR_I2C_SCL: length 97.1
  TOP w0.121: R58.1 143.8,72.81 140.88,72.81 140.56,72.49 139.42,72.49 138.85,71.92 138.28,71.92 137.39,71.03 137.39,68.79 137.26,68.67 125.89,68.67 119.67,62.44 v1(119.67,60.04)
  TOP w0.203: U4.11 91.25,30.11 91.37,29.99 91.75,29.99 v1(93.26,28.49)
  BOTTOM w0.121: v1(93.26,28.49) 93.57,28.17 95.35,28.17 101.82,21.69 106.53,21.69 108.64,23.8 108.64,25.83 111.61,28.81 111.61,38.45 120.12,46.96 120.12,59.59 v1(119.67,60.04)
PMICSR_I2C_SDA: length 95.3
  TOP w0.121: v1(121.1,59.85) 121.13,59.89 121.13,62.28 126.53,67.68 143.88,67.68 144.82,68.62 R59.1
  TOP w0.203: U4.10 90.85,30.01 91.48,29.37 91.71,29.37 92.44,28.64 v1(92.44,28.38)
  BOTTOM w0.121: v1(121.1,59.85) 121.1,58.93 120.37,58.2 120.37,46.84 111.86,38.33 111.86,28.69 108.89,25.71 108.89,23.67 106.66,21.45 101.72,21.45 95.24,27.92 92.88,27.92 92.44,28.36 v1(92.44,28.38)
PWR_SMPS1: length 5.2
  TOP w0.121: U4.35 87.65,36.77
  TOP w0.203: 87.54,37.63 87.65,37.52 87.65,36.77
  TOP w0.508: 87.54,37.63 87.54,39.15 86.83,39.87 85.13,39.87
PWR_SMPS1_FB: length 51.7
  TOP w0.203: U4.32 88.85,37.77 88.73,37.88 88.73,38.54
  TOP w0.381: 88.73,38.54 88.43,38.85 v1(88.43,39.28) 88.81,39.66 R562.2 ; 72.68,78.27 v1(72.05,78.27)
  LY4 w0.381: v1(88.43,39.28) 88.43,44.49 81.44,51.47 81.44,59.35 82.97,60.87 82.97,65.44 80.7,67.71 80.16,67.71 73.33,74.53 73.33,75.08 73.32,75.09 73.32,77 v1(72.05,78.27)
PWR_SMPS2: length 4.4
  TOP w0.203: U4.42 85.71,33.89 85.51,33.69
  TOP w0.381: L3.1 83.02,33.9 83.22,33.69 85.51,33.69
PWR_SMPS3: length 4.3
  TOP w0.203: U4.31 89.25,38.27 89.57,38.59 89.57,39.03
  TOP w0.508: L8.1 90.23,40.48 90.23,39.68 89.57,39.03
PWR_SWIO: length 3.2
  TOP w0.203: U4.14 92.81,31.89 92.83,31.91 93.17,31.91 93.19,31.89 94.84,31.89 L4.1
PWR_VAUX1: length 4.8
  TOP w0.203: U4.46 85.81,32.29 85.68,32.16 85.67,32.16 85.6,32.09 85.2,32.09
  TOP w0.508: R474.1 v1(84.62,30.77) 84.62,31.51 85.2,32.09
  BOTTOM w0.508: C109.1 v1(84.62,30.77)
PWR_VAUX2: length 5.3
  TOP w0.203: 86.37,31.49 86.37,31.39 ; 86.37,31.39 U4.48 ; 86.37,31.39 86.37,30.74
  TOP w0.508: 86.37,30.74 85.89,30.27 85.89,30.14 85.88,30.13 85.88,29.75 85.38,29.25 v1(84.62,29.25) R475.1
  BOTTOM w0.508: C110.1 v1(84.62,29.25)
PWR_VAUX33: length 6.1
  TOP w0.203: v1(87.67,28.59) 87.82,28.74 87.82,28.89 88.18,29.25 88.18,29.54 88.35,29.72 88.35,30.02 88.45,30.11 U4.4
  TOP w0.508: R466.1 94.64,28.61 v1(94.14,28.61)
  TOP w0.635: R466.1 R463.2
  BOTTOM w0.508: C108.1 v1(87.67,28.59)
PWR_VDAC: length 2
  TOP w0.508: R471.1 v1(95.97,36.11)
  BOTTOM w0.508: C101.1 96.1,36.23 v1(95.97,36.11)
PWR_VDD1_SMPS: length 9.5
  TOP w0.508: R469.2 82.14,42.19 83.22,43.27 L2.2 88.63,43.27
  BOTTOM w0.508: C237.1 v1(85.87,45.11)
PWR_VDD2_SMPS: length 14.5
  TOP w0.203: 84.61,33.17 85.72,33.17 85.81,33.09 U4.44
  TOP w0.381: 84.61,33.17 84.37,32.93
  TOP w0.508: 84.37,32.93 84.37,32.3 83.86,31.79 80.17,31.79 79.62,32.34 L3.2 79.12,35.21 R468.2
  BOTTOM w0.508: v1(78.02,33.82) 78.38,34.18 C239.1
PWR_VDD3_SMPS: length 1.4
  TOP w0.203: 89.65,36.67 89.65,38.08
  vias: v1(90.36,38.67)
PWR_VDDIO: length 8.5
  TOP w0.203: 92.72,30.34 92.44,30.62 91.76,30.62 ; 91.76,30.62 91.65,30.62 ; 91.76,30.62 91.73,30.64
  TOP w0.762: R465.2 R466.2 96.95,28.98 96.63,29.3 95.06,29.3 94.93,29.42 93.64,29.42 92.72,30.34
PWR_VDIG1: length 5
  TOP w0.203: v1(89.95,28.61) 89.65,28.92 89.65,30.72
  BOTTOM w0.635: v1(89.95,28.61) 89.72,28.61 89.45,28.34 C104.1 89.51,27.66 90.92,27.66 R464.2
PWR_VDIG2: length 4.8
  TOP w0.203: U4.5 88.85,30.04 88.68,29.88 88.68,28.86 88.18,28.36 C103.1
  TOP w0.635: R476.2 89.31,27.72 C103.1
PWR_VIO_SMPS: length 8.8
  TOP w0.203: U4.16 93.19,32.69 v1(93.46,32.42)
  BOTTOM w0.508: v1(100.75,31.66) 100.73,31.68 C241.1 96.54,31.68 95.8,32.42 v1(93.46,32.42)
PWR_VMMC: length 3.4
  TOP w0.508: 86.14,27.72 C107.1
  TOP w0.762: R477.2 86.14,27.72
PWR_VPLL: length 6.7
  TOP w0.203: 92.52,36.51 92.52,35.89
  TOP w0.381: v1(95.87,37.88) 94.73,36.74 92.75,36.74 92.52,36.51
  TOP w0.508: R473.1 v1(95.87,37.88)
  BOTTOM w0.508: C102.1 v1(95.87,37.88)
PWRMON_I2CSCL: length 23.6
  TOP w0.121: v1(73.51,38.14) 70.65,38.14 69.99,37.47 66.46,37.47 65.98,36.99 65.89,36.99 64.81,35.91 64.81,34.71 64.25,34.15 U32.5
  BOTTOM w0.121: U27.5 72.01,46.03 72.27,45.77 72.27,45.66 72.94,45 73.32,45 73.57,44.74 J17.1 R453.1 72.94,40.8 72.94,38.71 v1(73.51,38.14)
PWRMON_I2CSDA: length 19.7
  TOP w0.121: v1(70.01,38.14) 69.6,37.72 66.36,37.72 66.07,37.44 65.63,37.44 64.43,36.23 64.43,35.15 63.93,34.65 U32.4
  BOTTOM w0.121: v1(70.01,38.14) 70.33,38.45 70.33,40.61 R454.1 J17.2 71.03,45.5 70.9,45.63 70.9,46.27 71.16,46.53 U27.4
RS232_CTS: length 15.3
  TOP w0.121: U18.8 v1(108.6,14.13)
  BOTTOM w0.121: v1(108.6,14.13) 114.85,14.13 117.27,11.71 J12.8
RS232_RTS: length 15.2
  TOP w0.121: U18.7 v1(108.62,15.4)
  BOTTOM w0.121: J12.7 114.5,11.17 113.32,12.36 108.75,12.36 107.73,13.37 107.73,14.52 v1(108.62,15.4)
RS232_RXD: length 10.8
  TOP w0.121: U18.13 113.26,19.21 113.6,18.87 113.6,17.03 113.96,16.67 113.96,11.25 J12.2
RS232_TXD: length 13
  TOP w0.121: U18.14 114.08,20.48 115.1,19.47 115.1,11.2 J12.3
RTC_PORZ: length 10
  TOP w0.121: U33.3 62.18,105.92 62.43,106.17 v1(63.09,106.17) ; U3.2 61.16,100.11 60.93,100.34 v1(60.49,100.34)
  BOTTOM w0.121: v1(63.09,106.17) 62.39,105.47 62.39,103.06 60.49,101.15 v1(60.49,100.34)
RTCK: length 2.8
  TOP w0.121: J2.9 v1(22.14,91.73)
  BOTTOM w0.121: v1(22.14,91.73) R74.1
SDIO_GPMC_A1: length 108.8
  TOP w0.121: v1(35.98,108.98) 35.98,107.48 33.69,105.19 24.55,105.19 24.28,105.46 24.28,105.76 24.27,105.76 U28.18 ; v1(92.7,125.84) 89.67,125.84 88.86,125.03 88.86,125.01 88.36,124.51 87.07,124.51 86.83,124.75 66.71,124.75 66.2,125.26 66.2,125.7 65.38,126.53 61.42,126.53 61.01,126.11 61.01,125.17 60.35,124.52 60.08,124.52 60.07,124.51 59.13,124.51 59.12,124.52 58.05,124.52 57.78,124.25 44.35,124.25 v1(42.46,126.15) ; R196.2 v1(92.77,128.71)
  BOTTOM w0.121: v1(42.46,126.15) 42.1,126.5 40.74,126.5 40.62,126.38 40.62,121.55 40.49,121.42 39.99,121.42 39.86,121.55 39.86,125.28 39.74,125.41 39.15,125.41 39.03,125.28 39.03,121.5 38.9,121.37 38.52,121.37 38.39,121.5 38.39,123.63 38.26,123.76 37.78,123.76 37.65,123.63 37.65,112.91 36.61,111.86 36.61,109.61 v1(35.98,108.98) ; v1(92.77,128.71) 92.43,128.37 92.43,126.13 92.7,125.87 v1(92.7,125.84)
SDIO_GPMC_A2: length 108.5
  TOP w0.121: R198.2 v1(92.77,129.73) ; v1(36.61,108.44) 36.61,107.53 33.9,104.81 23.53,104.81 23.27,105.07 U28.16 ; v1(41.06,125.77) 41.06,124.67 41.73,124 60.69,124 62.16,122.53 65.54,122.53 66.03,123.01 66.12,123.01 66.14,123.04 69.71,123.04 70.62,123.95 74.81,123.95 75.22,123.54 77.82,123.54 78.52,124.24 86.63,124.24 86.87,124.01 88.68,124.01 89.17,124.5 92.26,124.5 v1(92.77,125.01)
  BOTTOM w0.121: v1(92.77,129.73) 92.19,129.14 92.19,125.59 v1(92.77,125.01) ; v1(41.06,125.77) 41.06,118.93 40.93,118.81 40.55,118.81 40.42,118.93 40.42,120.94 40.3,121.07 39.86,121.07 39.74,120.94 39.74,118.27 39.61,118.14 39.1,118.14 38.98,118.27 38.98,120.76 38.85,120.89 38.47,120.89 38.34,120.76 38.34,113.24 36.86,111.76 36.86,109.51 36.61,109.26 v1(36.61,108.44)
SDIO_GPMC_A3: length 107.9
  TOP w0.121: v1(34.07,115.58) 34.07,113.68 30.03,109.64 26.45,109.64 26.19,109.37 U28.23 ; v1(92.87,127.34) 92.52,127.34 92.24,127.06 R202.2
  LY3 w0.133: v1(34.07,115.58) 34.07,120.51 35.56,121.99 49.72,121.99 49.85,121.86 49.85,121.22 49.72,121.09 37.48,121.09 37.35,120.97 37.35,120.48 37.48,120.36 50.48,120.36 50.61,120.48 50.61,121.86 50.74,121.99 66.04,121.99 67.46,123.41 68.96,123.41 70.04,124.5 88.73,124.5 91.58,127.34 v1(92.87,127.34)
SDIO_GPMC_BE1N: length 110.8
  TOP w0.121: v1(96.86,126.96) 96.81,126.91 93.99,126.91 93.36,126.28 88.8,126.28 88.3,126.78 66.98,126.78 66.97,126.77 58.29,126.77 58.15,126.91 53.82,126.91 52.37,128.36 39.96,128.36 39.84,128.48 v1(39.84,129.09) ; U28.22 26.07,108.87 26.45,109.26 34.4,109.26 34.89,109.74 v1(34.89,109.77) ; v1(97.04,142.84) 96.61,142.4 R186.2
  BOTTOM w0.121: v1(96.86,126.96) 96.86,126.96 97.33,127.43 97.33,128.5 96.77,129.07 96.77,134.76 97.78,135.78 97.78,142.09 v1(97.04,142.84) ; v1(34.89,109.77) 34.89,111.92 36.2,113.24 36.2,113.25 36.36,113.41 36.36,126.45 36.49,126.58 37.5,126.58 37.63,126.45 37.63,126.08 37.76,125.96 38.9,125.96 39.03,126.08 39.03,128.28 v1(39.84,129.09)
SDIO_GPMC_CLK: length 110.9
  TOP w0.121: R181.2 v1(117.13,95.03) ; U28.19 25.77,107.37 v1(25.79,107.35)
  LY3 w0.133: v1(25.79,107.35) 27.22,105.93 47.2,105.93 50.84,109.56 61.71,109.56 61.95,109.32 65.15,109.32 66.15,110.32 84.16,110.32 84.44,110.04 90.05,110.04 90.33,110.32 99.58,110.32 100.09,110.83 103.97,110.83 104.86,109.94 116.09,109.94 v1(117.16,108.88)
  BOTTOM w0.121: v1(117.13,95.03) 117.13,105.45 117.26,105.57 117.26,108.77 v1(117.16,108.88)
SDIO_GPMC_CS3N: length 110.1
  TOP w0.121: v1(95.78,141.77) 95.78,141.99 94.48,143.29 v1(93.89,143.29) ; v1(96.86,127.83) 94.56,127.83 93.26,126.53 88.93,126.53 88.42,127.04 60.23,127.04 60.11,127.16 54.08,127.16 52.44,128.8 v1(40.63,128.8) ; v1(35.98,109.97) 34.76,108.75 32.14,108.75 30.24,106.85 26.75,106.85 26.4,107.2 26.4,107.66 26.19,107.87 U28.20
  BOTTOM w0.121: v1(40.63,128.8) 39.79,127.96 39.79,126.5 37.08,123.79 37.08,112.88 35.98,111.78 v1(35.98,109.97) ; v1(95.78,141.77) 97.38,140.17 97.38,135.96 96.53,135.11 96.53,134.87 96.52,134.86 96.52,128.24 96.86,127.9 v1(96.86,127.83) ; v1(93.89,143.29) R187.2
SYS_RESETN: length 323.7
  TOP w0.102: U2.A10 77.49,85.4 77.1,85.79
  TOP w0.121: R306.1 132.73,31.41 v1(133.49,31.41) 133.9,31.41 134.61,30.69 U10.51 ; U26.2 v1(21.25,61.51) ; J3.26 134.17,92.98 137.04,92.98 137.98,93.92 139.3,93.92 140.15,94.77 141.38,94.77 142.05,94.1 v1(142.3,94.1) ; v1(17.56,51.29) 17.56,46.52 19.85,44.23 29.37,44.23 29.76,43.85 39.31,43.85 45.15,49.69 55.24,49.69 55.47,49.45 65.9,49.45 66.63,50.19 69.71,50.19 70,49.9 70.35,49.55 72.02,49.55 72.31,49.26 72.8,48.77 73.03,48.77 73.71,48.1 80.15,48.1 80.97,47.28 88.17,47.28 88.81,47.92 115.24,47.92 116.12,48.8 128.18,48.8 130.95,51.57 v1(134.56,51.57) ; 77.1,85.79 75.73,87.16 74.84,87.16 73.85,88.15 72.72,88.15 71.48,86.91 70.47,86.91 69.63,87.75 R10.2 69.23,88.9 69.05,88.9 67.76,90.19 65.92,90.19 65.66,89.94 65.65,89.94 65.43,89.71 65.29,89.71 65.29,89.71 63.75,89.71 63.36,90.1 60.29,90.1 59.98,90.4 56.69,90.4 55.28,91.81 48.82,91.81 47.11,90.09 32.94,90.09 32.55,89.7 32.55,86.66 31.91,86.02 31.91,85.5 31.15,84.75 24.68,84.75 v1(24.17,84.24) 23.98,84.05 23.21,84.05 22.32,84.94 21.05,84.94 20.48,85.51 R517.2
  BOTTOM w0.121: v1(133.49,31.41) 132.98,31.91 132.98,33.46 131.33,35.12 131.33,36.21 131.33,37.48 131.56,37.71 131.56,45.76 133.37,47.56 133.37,50.26 134.56,51.45 v1(134.56,51.57) 141.63,58.65 141.63,71.4 142.14,71.91 142.14,75.25 143.55,76.66 143.55,82.89 143.35,83.1 143.35,87.73 142.53,88.55 142.53,93.87 v1(142.3,94.1) ; 24.17,87.92 24.68,87.41 24.68,84.75 v1(24.17,84.24) 23.07,83.15 23.07,67.98 20.87,65.78 20.87,63.84 21.35,63.36 21.35,61.61 v1(21.25,61.51) 17.56,57.82 v1(17.56,51.29)
SYS_WARMRESETN: length 246.4
  TOP w0.121: v1(26.15,115.29) 26.21,115.35 28.13,115.35 29.76,116.98 40.65,116.98 41.51,117.83 65.78,117.83 66.66,116.96 72.94,116.96 73.93,117.94 90.31,117.94 93.54,114.71 100.81,114.71 102.58,112.94 109.4,112.94 110.42,111.92 117.13,111.92 121.07,115.86 122.24,115.86 122.77,115.33 v1(123,115.33) ; C117.1 10.88,59.35 SW2.3 SW2.4 v1(10.8,66.86) ; R10.1 68.1,89.01 68.1,89.5 67.66,89.94 66.02,89.94 65.77,89.69 65.76,89.69 65.53,89.46 65.4,89.46 65.39,89.46 60.03,89.46 59.33,90.16 56.27,90.16 54.87,91.56 48.93,91.56 47.21,89.85 33.84,89.85 32.85,88.86 32.85,85.91 31.33,84.38 26.85,84.38 26.27,83.8 23.12,83.8 23.05,83.86 22.53,84.38 18.2,84.38 16.24,86.35 v1(10.96,86.35)
  BOTTOM w0.121: v1(10.8,66.86) 11.09,67.14 11.09,84.11 10.96,84.24 v1(10.96,86.35) 11.47,86.85 11.47,96.94 13.25,98.72 21.8,98.72 26.23,103.15 26.23,115.2 v1(26.15,115.29) ; J4.11 128.18,111.72 126.94,112.97 126.94,114.95 126.55,115.33 v1(123,115.33)
TCK: length 2.8
  TOP w0.121: J2.11 v1(22.14,90.46)
  BOTTOM w0.121: v1(22.14,90.46) R75.1
TSC_CLK: length 48.8
  TOP w0.095: 50.96,60.49 49.19,60.49 J9.5
  TOP w0.121: R250.1 61.28,91.6 v1(60.87,92.01) ; v1(60.11,60.49) 50.96,60.49
  BOTTOM w0.121: v1(60.11,60.49) 60.11,69.31 63.36,72.57 63.36,81.31 62.98,81.7 62.98,83.13 62.31,83.79 62.31,86.7 61.59,87.42 61.59,87.53 61.59,88.42 60.45,89.56 60.45,91.62 60.84,92.01 v1(60.87,92.01)
TSC_GIO0: length 6
  TOP w0.121: TP38.1 44.11,61.38 46.39,63.66 J9.1
TSC_GIO1: length 6.1
  TOP w0.121: J9.3 46.9,62.39 44.49,59.98 TP39.1
TSC_GIO2: length 117.2
  TOP w0.121: v1(72.74,132.12) 73.19,132.12 73.32,131.99 R255.1 ; v1(71.92,133.64) 70.4,132.12 70.17,132.12 69.45,131.4 67.11,131.4 66.6,131.91 62.83,131.91 60.25,134.49 57.25,134.49 56.37,135.37 55.46,135.37 54.71,136.12 49.91,136.12 v1(49.59,136.44)
  BOTTOM w0.121: v1(71.92,133.64) 72.74,132.82 v1(72.74,132.12) ; v1(49.59,136.44) 49.59,134.91 50.58,133.92 50.58,116.52 51.14,115.96 51.14,108.06 50.66,107.58 47.38,107.58 44.59,104.79 44.59,103.48 44.56,103.46 44.56,98.88 43.97,98.29 43.71,98.02 43.71,96.3 43.83,96.18 43.83,93.98 43.9,93.9 43.9,92.5 43.91,92.5 43.91,92.3 44.38,91.83 44.38,82.2 41.74,79.56 41.74,71.46 47.68,65.53 49.73,65.53 50.96,64.3 50.96,61 49.82,59.85
TSC_I2CSCL: length 71.2
  TOP w0.121: v1(43.06,94.12) 44.39,94.12 44.84,93.66 47.36,93.66 47.8,94.1 50.79,94.1 53.04,96.34 57.39,96.34 58.68,97.63 61.32,97.63 61.68,98 63.09,98 63.49,97.6 64.47,97.6 64.97,98.09 66.68,98.09 70,98.09 70.29,97.8 71.3,96.8 71.69,96.8 71.93,96.56 72.3,96.56 R244.1
  BOTTOM w0.121: v1(43.06,94.12) 43.66,93.53 43.66,92.4 43.66,92.39 43.66,92.2 44.08,91.78 44.08,82.43 41.5,79.84 41.5,71.2 47.66,65.04 49.73,65.04 50.72,64.05 50.72,63.29 49.82,62.39
TSC_I2CSDA: length 2.6
  TOP w0.121: 49.82,61.12 51.22,61.12 51.6,61.51 52.23,61.51
TSC_RSV0: length 5.9
  TOP w0.121: J9.7 47.15,59.85 45.12,57.82 TP40.1
TSC_RSV1_VREF: length 6
  TOP w0.381: J9.9 47.15,58.58 45,56.43 TP41.1
UART0_CTSN: length 193.1
  TOP w0.121: R364.1 79.21,104.1 79.21,104.81 79.51,105.12 79.51,107.05 78.45,108.11 66.94,108.11 66.1,107.28 v1(61.58,107.28) ; v1(52.69,6.11) 53.23,5.57 59.04,5.57 60.03,6.56 92.98,6.56 96.08,9.67 99.97,9.67 102.02,11.72 109,11.72 110.27,12.99 110.27,13.88 110.53,14.13 U18.9
  BOTTOM w0.121: v1(52.69,6.11) 52.69,7.04 52.7,7.05 52.7,22.87 55.81,25.99 55.81,39.73 55.5,40.04 55.5,41.57 56.4,42.47 56.4,57.51 57.42,58.53 57.42,69.55 60.72,72.85 60.72,80.82 60.72,82.23 60.09,82.87 60.09,85.69 59.35,86.42 59.35,87.51 58.66,88.2 58.23,88.64 58.23,88.64 58.23,92.59 58.31,92.68 58.31,93.15 58.31,101.47 59.47,102.63 59.47,105.17 v1(61.58,107.28)
UART0_RTSN: length 189.5
  TOP w0.121: v1(78.09,104.15) 78.09,103.51 78.9,102.7 78.9,102.68 79.03,102.55 79.03,101.38 R362.1 ; U18.10 110.4,15.4 110.02,15.02 110.02,13.25 108.88,12.1 102.02,12.1 99.83,9.92 95.98,9.92 92.87,6.81 59.63,6.81 58.83,6.02 v1(53.49,6.02)
  LY3 w0.133: v1(61.84,103.95) 62.28,103.95 62.43,103.81 64.59,103.81 65.37,104.58 69.09,104.58 69.26,104.75 73.58,104.75 74.18,104.15 v1(78.09,104.15)
  BOTTOM w0.121: v1(53.49,6.02) 53.49,6.88 52.95,7.43 52.95,22.77 56.06,25.88 56.06,40.71 56.89,41.54 56.89,57.27 57.92,58.3 57.92,69.22 61.22,72.52 61.22,82.44 60.58,83.07 60.58,85.89 60.13,86.34 60.13,86.34 59.84,86.63 59.84,87.72 58.72,88.84 58.72,88.84 58.72,92.38 58.81,92.47 58.81,93.36 58.81,101.08 60.45,102.71 60.45,104.07 60.71,104.34 61.44,104.34 v1(61.84,103.95)
UART0_RXD: length 204.9
  TOP w0.121: v1(44.68,93.13) 47.17,93.13 47.9,93.85 52.74,93.85 53.38,94.49 55.88,94.49 58.78,97.39 61.42,97.39 61.78,97.75 62.98,97.75 63.39,97.35 64.57,97.35 65.07,97.85 66.58,97.85 69.9,97.85 71.2,96.55 71.59,96.55 71.65,96.49 72.34,95.8 72.76,95.8 73.28,96.32 77.39,96.32 77.61,96.1 v1(77.69,96.1) ; v1(49.74,7.23) 50.67,7.23 50.68,7.24 53.84,7.24 54.52,6.56 58.53,6.56 59.4,7.42 92.64,7.42 95.64,10.42 99.19,10.42 101.51,12.74 108.42,12.74 109.38,13.7 109.38,17.18 110.15,17.94 U18.12 ; v1(77.18,99) 77.18,98.91 78.02,98.08 R363.1
  BOTTOM w0.121: v1(77.18,99) 77.18,99 76.88,98.69 76.88,96.48 77.25,96.1 v1(77.69,96.1) ; v1(49.74,7.23) 49.44,7.53 49.44,44.87 51.09,46.52 51.09,51.1 51.72,51.73 51.72,65.7 50.83,66.59 47.94,66.59 42.87,71.66 42.87,78.9 44.25,80.28 44.87,80.91 44.87,92.49 44.68,92.69 v1(44.68,93.13)
UART0_TXD: length 196.4
  TOP w0.121: U18.11 110.02,16.67 109.64,16.29 109.64,13.49 108.63,12.48 101.76,12.48 99.45,10.17 95.74,10.17 92.75,7.17 59.5,7.17 58.63,6.31 54.42,6.31 53.73,7 51.04,7 50.71,6.67 v1(49.19,6.67) ; v1(44.16,97.85) 44.87,98.56 55.11,98.56 55.79,97.88 61.21,97.88 61.58,98.25 63.19,98.25 63.59,97.84 64.37,97.84 64.87,98.34 70.52,98.34 R361.1
  BOTTOM w0.121: v1(44.16,97.85) 44.16,92.41 44.63,91.94 44.63,81.01 42.62,79.01 42.62,71.42 47.79,66.25 50.54,66.25 51.47,65.32 51.47,51.83 50.84,51.2 50.84,46.65 49.19,45 v1(49.19,6.67)
USB0_CONN_DM: length 6.6
  TOP w0.114: L5.3 132.54,160.39 132.4,160.54 132.4,160.97 132.32,161.05 132.32,161.42 132.37,161.47 U23.2 132.37,162.06 132.12,162.32 131.43,162.32 131.18,162.57 131.18,164.78 131.37,164.97 J14.2
USB0_CONN_DP: length 6.4
  TOP w0.114: L5.4 131.69,160.63 132.04,160.98 132.04,161.3 131.87,161.47 U23.1 131.86,161.89 131.47,161.89 130.9,162.46 130.9,164.78 130.72,164.96 J14.3
USB0_DM: length 98.3
  TOP w0.114: L5.2 132.54,157.9 132.26,157.61 132.26,156.71 v1(132.54,156.43) ; v1(112.69,104.87) 112.5,104.87 111.8,105.57 92.62,105.57 91.86,104.81 91.86,100.89 89.95,98.98 89.95,96.56 89.55,96.15 89.55,95.53 88.35,94.33 88.35,94.32 87.96,93.93 87.96,91.96 U2.N18
  BOTTOM w0.114: v1(132.54,156.43) 132.54,156.41 132.24,156.12 132.24,154.22 122.97,144.94 122.97,135.91 116.62,129.56 116.62,126.76 114.85,124.99 114.85,108.86 112.5,106.52 112.5,105.05 v1(112.69,104.87)
USB0_DP: length 98.1
  TOP w0.114: L5.1 131.69,157.9 131.98,157.61 131.98,156.71 v1(131.7,156.43) ; v1(111.92,104.81) 111.44,105.29 92.74,105.29 92.14,104.7 92.14,100.77 90.23,98.87 90.23,96.44 89.83,96.03 89.83,95.41 88.63,94.22 88.63,94.2 88.24,93.82 88.24,91.85 88.24,91.84 88.24,91.25 87.99,91 U2.N17
  BOTTOM w0.114: v1(111.92,104.81) 112.22,105.11 112.22,106.64 114.57,108.98 114.57,125.1 116.34,126.88 116.34,129.68 122.69,136.03 122.69,145.06 131.96,154.33 131.96,156.16 v1(131.7,156.43)
USB0_ID: length 114.5
  TOP w0.102: U2.P16 v2(89,90.6)
  TOP w0.121: J14.4 130.07,164.44 130.09,164.42 130.09,164.1 v1(129.75,163.77) 130.64,162.88 130.64,159.09 R571.1 128.94,157.39 v1(128.94,149.33) ; v1(116.56,102.02) 116.12,102.02 115.98,101.88 113.39,101.88 113.09,101.58 108.3,101.58 106.78,103.09 96.36,103.09 94.76,101.49 94.76,98.34 93.51,97.09 v1(93.51,96.56) ; R381.2 133.95,161.88 U23.3 132.88,161.87 v1(132.88,161.2)
  LY3 w0.133: v1(132.88,161.2) 130.31,163.77 v1(129.75,163.77)
  BOTTOM w0.102: 89.64,92.9 89.64,91.24 v2(89,90.6)
  BOTTOM w0.121: v1(128.94,149.33) 127.93,148.31 127.93,147.74 126.31,146.12 126.31,141.84 123.58,139.1 123.58,135.7 121,133.13 121,132.06 118.72,129.77 118.72,127.1 116.56,124.94 v1(116.56,102.02) ; v1(93.51,96.56) 93.51,96.3 93.32,96.12 92.75,96.12 90.91,94.27 89.9,94.27 89.64,94.01 89.64,92.9
USB0_MEAS_IDN: length 2.8
  TOP w0.121: Q5.G 125.56,161.89 R565.1 R566.1
USB0_OVRCURN: length 4.5
  TOP w0.121: R384.2 v1(140.25,151.36) 140.25,150.91 139.55,150.21 R382.2 138.71,149.95 U22.5
USB1_CONN_DM: length 6.9
  TOP w0.114: L6.3 148.1,159.53 147.95,159.68 147.95,160.11 147.88,160.18 147.88,160.55 147.93,160.61 U30.2 147.93,161.2 147.68,161.45 146.99,161.45 146.73,161.71 146.73,162.22 146.34,162.61 146.34,164.4 J18.2
USB1_CONN_DP: length 7
  TOP w0.114: J18.3 146.06,163.9 146.06,162.49 146.46,162.1 146.46,161.59 147.03,161.02 147.42,161.02 U30.1 147.43,160.61 147.6,160.44 147.6,160.11 147.25,159.77 L6.4
USB1_DM: length 122.4
  TOP w0.102: U2.R18 89.4,92.9
  TOP w0.114: v1(97.8,124.05) 98.08,124.33 98.08,124.56 98.36,124.84 100.46,124.84 101.07,125.45 102.21,125.45 103.54,124.12 112.37,124.12 112.81,123.67 123.04,123.67 123.54,124.18 123.99,124.18 124.31,124.5 124.31,124.94 124.97,125.6 137.49,125.6 138.47,124.62 139.99,124.62 v1(140.12,124.5) ; v1(149.51,151.55) 149.22,151.83 149.22,154.2 147.81,155.61 147.81,156.75 148.1,157.03 L6.2 ; v1(90.08,93.83) 89.89,93.83 89.55,93.49 89.55,93.05 89.4,92.9
  BOTTOM w0.114: v1(140.12,124.5) 139.6,125.02 139.6,125.92 142.53,128.85 142.53,136.44 144.33,138.24 144.33,145.21 146.3,147.18 146.3,148.38 147.66,149.74 148.74,149.74 149.22,150.23 149.22,151.27 v1(149.51,151.55) ; v1(97.8,124.05) 98.08,123.77 98.08,123.43 98.31,123.2 98.31,116.8 97.62,116.12 97.62,103.45 95.69,101.52 95.69,96.2 95.21,95.72 92.96,95.72 90.88,93.64 90.27,93.64 v1(90.08,93.83)
USB1_DP: length 122.4
  TOP w0.102: 89.79,92.9 89.67,92.78 89.67,92.21 89.76,92.11 89.76,91.35 89.41,91 U2.R17
  TOP w0.114: v1(98.64,124.05) 98.36,124.33 98.36,124.45 98.47,124.56 100.57,124.56 101.18,125.17 102.09,125.17 103.43,123.84 112.25,123.84 112.7,123.39 123.15,123.39 123.66,123.9 124.1,123.9 124.59,124.38 124.59,124.83 125.08,125.32 137.37,125.32 138.35,124.34 139.32,124.34 v1(139.6,124.06) ; L6.1 147.25,157.03 147.53,156.75 147.53,155.5 148.94,154.09 148.94,151.83 v1(148.66,151.55) ; 89.79,92.9 89.95,93.06 90.1,93.06 v1(90.12,93.08)
  BOTTOM w0.114: v1(148.66,151.55) 148.94,151.27 148.94,150.34 148.63,150.02 147.55,150.02 146.02,148.5 146.02,147.29 144.06,145.33 144.06,138.35 142.25,136.55 142.25,128.97 139.32,126.04 139.32,124.34 v1(139.6,124.06) ; v1(90.12,93.08) 90.16,93.08 90.44,93.36 90.99,93.36 93.08,95.44 95.33,95.44 95.97,96.09 95.97,101.41 97.9,103.34 97.9,116 98.59,116.69 98.59,123.31 98.36,123.54 98.36,123.77 v1(98.64,124.05)
USB1_ID: length 123.7
  TOP w0.102: U2.P17 88.6,91.01 89,91.41 89,91.99 88.87,92.11 88.87,92.78 88.94,92.84 88.94,92.9
  TOP w0.121: v1(140.25,161.2) 144.5,161.2 145.58,160.12 v1(146.79,160.12) ; v1(148.56,160.18) 148.43,160.32 U30.3 149.26,161.02 149.27,161.01 R385.2 ; v1(100.7,102.63) 96.59,102.63 95.01,101.05 95.01,98.24 93.95,97.18 93.95,96.12 93.75,95.92 92.21,95.92 90.56,94.27 89.7,94.27 88.94,93.51 88.94,92.9
  LY3 w0.133: v1(140.25,156.37) 139.42,155.55 133.2,155.55 130.72,153.07 v1(108.24,153.07)
  LY4 w0.133: v1(108.24,153.07) 106.15,150.98 106.15,121.66 105.77,121.28 105.77,114.51 104.05,112.79 104.05,105.51 102.51,103.97 102.04,103.97 v1(100.7,102.63)
  BOTTOM w0.121: v1(148.56,160.18) 148.44,160.31 146.98,160.31 v1(146.79,160.12) ; v1(140.25,156.37) v1(140.25,161.2)
USB1_OVRCURN: length 76.2
  TOP w0.121: v1(130.09,150.02) 130.09,149.96 131.8,148.25 137.01,148.25 137.32,148.56 138.48,148.56 138.64,148.73 139.51,148.73 140.37,147.87 145.39,147.87 145.64,148.12 U29.5 145.64,150.85 R412.2 ; v1(125.32,141.83) 122.4,141.83 117.96,146.28 106.46,146.28 103.86,143.67 99.29,143.67 99.03,143.93 96.67,143.93 96.64,143.96 96.27,143.96 96.24,143.93 v1(94.84,143.93)
  BOTTOM w0.121: v1(125.32,141.83) 125.32,146.53 128.82,150.02 v1(130.09,150.02) ; v1(94.84,143.93) 94.84,136.24 94.59,135.99 94.59,134.85 94.91,134.53 R410.2
VADDL_PHY: length 10
  TOP w0.203: U25.44 v1(32.58,59.1) ; U25.19 v1(33.38,51.09) ; U25.13 v1(30.98,51.22) ; U25.8 v1(29.28,54.56)
  TOP w0.508: v1(28.99,65.95) 28.5,65.95 FB16.1 28.34,65.06 v1(28.99,65.06)
  BOTTOM w0.635: C199.1 30.23,54.56 v1(29.28,54.56) ; C198.1 32.58,58.3 v1(32.58,59.1)
  BOTTOM w0.762: C200.1 30.98,51.81 v1(30.98,51.22) ; C201.1 33.57,51.35 33.38,51.16 v1(33.38,51.09)
VAUX1: length 274.3
  TOP w0.508: R474.2 81.06,30.77 80.79,31.04 79.78,31.04 79.44,30.7 v1(79.44,30.23) 78.17,30.23 76.62,31.79 v1(51.85,31.79) ; R502.1 117.32,141.1 v1(117.32,139.8) ; v1(101.89,124.62) 101.26,123.99 100.05,123.99 99.16,123.1 95.74,123.1 95.49,122.85 90.26,122.85 89.55,122.13 84.03,122.13 83.1,121.2 75.75,121.2 73.52,118.96 56.44,118.96 56.24,119.16 v1(55.6,119.16) ; v1(113.45,135.04) 110.21,135.04 106.55,138.7 v1(103.01,138.7) ; v1(55.6,86.91) 55.12,87.39 48.81,87.39 v1(48.7,87.28)
  TOP w0.635: J19.16 118.97,24.36 117.96,25.37 v1(117.13,25.37)
  BOTTOM w0.508: v1(113.45,135.04) 113.45,138.4 114.34,139.29 116.81,139.29 v1(117.32,139.8) ; v1(51.85,31.79) 51.85,51.22 53.06,52.42 v1(53.06,55.03) 53.06,61.82 53.63,62.39 53.63,71.99 51.16,74.47 51.16,79.19 48.59,81.76 48.59,86.53 48.7,86.65 v1(48.7,87.28) ; v1(55.6,119.16) 55.76,119 55.76,95.54 55.41,95.19 55.41,91.34 55.76,90.98 55.76,87.07 v1(55.6,86.91) ; v1(101.89,124.62) 101.64,124.88 101.64,134.02 103.01,135.39 v1(103.01,138.7)
  BOTTOM w0.635: v1(79.44,30.23) 79.44,28.52 78.65,27.72 78.65,24.99 79.98,23.66 80.05,23.66 81.19,22.52 81.19,20.1 81.83,19.47 87.03,19.47 87.86,18.64 92.94,18.64 94.21,19.91 107.03,19.91 109.89,22.77 109.89,25.18 111.16,26.45 114.15,26.45 115.23,25.37 v1(117.13,25.37)
VAUX2: length 408
  TOP w0.508: v1(78.46,28.74) 79.41,28.74 80.17,29.5 81.34,29.5 81.6,29.25 R475.2 ; v1(76.34,48.54) 80.34,48.54 81.15,47.73 87.98,47.73 88.62,48.36 99.49,48.36 v1(99.99,48.86) v1(114.59,48.86) 115.48,48.86 117.52,50.9 124.12,50.9 v1(125.58,52.36) 129.51,52.36 131.29,54.14 150.15,54.14 v1(150.28,54.01) ; v1(17.88,41.06) 52.55,41.06 54.84,43.34 58.58,43.34 60.04,41.88 76.05,41.88 v1(76.81,42.65) ; 48.23,83.41 48.23,82.65 47.85,82.27 v1(22.2,82.27) ; 48.23,83.41 v1(46.58,85.06) ; 48.23,83.41 54.07,83.41 v1(56.23,85.57) ; FB20.2 124.37,140.56 124.37,137.58 125.96,135.99 144.88,135.99 v1(144.94,135.93)
  BOTTOM w0.508: J19.17 125.58,23.66 v1(125.58,52.36) ; v1(99.99,48.86) 99.99,48.87 99.67,49.19 R68.2 ; v1(46.58,85.06) 46.58,88.3 49.22,90.94 50.38,90.94 51.35,91.91 FB8.2 ; v1(76.34,48.54) 76.34,46.1 76.81,45.63 v1(76.81,42.65) 76.81,40.93 79.16,38.58 79.16,36.3 76.46,33.6 76.46,29.53 77.25,28.74 v1(78.46,28.74) ; v1(22.2,82.27) 22.2,68.05 16.61,62.46 16.61,46.14 16.17,45.69 16.17,42.77 v1(17.88,41.06) ; v1(144.94,135.93) 144.94,119.16 145.78,118.32 145.78,107.3 145.66,107.17 145.66,100.6 144.59,99.53 144.59,96.29 145.74,95.13 145.93,95.13 147.08,93.99 147.08,89.6 149.52,87.16 149.52,85.37 150.28,84.6 v1(150.28,54.01) ; FB2.2 v1(56.23,85.57)
  BOTTOM w0.635: v1(114.59,48.86) 114.59,55.09 FB6.2
VAUX33: length 211.2
  TOP w0.762: v1(149.96,53.25) 131.61,53.25 129.83,51.47 v1(126.34,51.47) ; R504.1 112.81,138.5 112.81,136.75 114.34,135.23 v1(144.18,135.23) ; R463.1 97.14,26.26 100.49,26.26 100.58,26.35 105.35,26.35 106.21,27.22 113.45,27.22 120.88,19.78 123.23,19.78 J19.18
  BOTTOM w0.762: v1(149.96,53.25) 149.52,53.7 149.52,84.29 148.55,85.25 148.55,86.73 146.32,88.96 146.32,93.67 145.69,94.3 145.5,94.3 143.7,96.1 143.7,99.88 144.69,100.87 144.69,108.16 144.89,108.36 144.89,117.03 145.02,117.17 145.02,117.94 144.18,118.78 v1(144.18,135.23) ; v1(126.34,51.47) 126.34,21.88 J19.18
VBCKUPBAT: length 16
  TOP w0.203: 90.85,36.77 90.85,37.26 91.31,37.73 91.95,37.73 92.35,38.14
  TOP w0.508: 92.35,38.14 94.13,38.14 98.07,42.07 TP26.1 BT1.1
VCOM_BAT: length 23.8
  TOP w0.381: J11.7 12.61,111.67 v1(12.36,111.42) 12.74,111.04 14.07,111.04
  TOP w0.508: U17.4 13.5,102.91 R359.2 C171.1 16.06,103.03 C172.1 v1(16.69,101.02)
  BOTTOM w0.508: C161.1 12.48,111.54 v1(12.36,111.42) 12.36,107.1 16.69,102.76 v1(16.69,101.02)
VCOM_BATEN: length 2.3
  TOP w0.508: R358.1 12.58,98.21 11.7,99.1
VCOM_BATFB: length 4.7
  TOP w0.508: U17.5 13.5,104.18 R359.1 C171.2 R360.2
VDAC: length 272.4
  TOP w0.508: v1(166.66,50.9) 165.86,50.1 161.84,50.1 161.14,50.8 161.14,56.29 159.49,57.95 152.21,57.95 151.24,58.91 141.69,58.91 141.32,59.28 129.26,59.28 127.27,61.27 123.02,61.27 121.89,60.15 121.89,59.75 117.81,55.66 v1(110.53,55.66) ; R471.2 v1(108.88,36.11) 109.51,36.11 109.57,36.04 v1(121.07,36.04) ; v1(165.77,124.18) 145.45,124.18 145.01,124.62 141.83,124.62 140.31,126.15 130.77,126.15 130.68,126.24 128.35,126.24 125.83,128.75 121.13,128.75 118.85,126.47 115.57,126.47 115.41,126.62 110.88,126.62 109.23,128.28 v1(103.45,128.28)
  BOTTOM w0.508: v1(165.77,124.18) 165.77,90.52 167.68,88.62 167.68,60.21 166.66,59.19 v1(166.66,50.9) ; v1(103.45,128.28) 103.45,121.04 104.81,119.67 104.81,115.8 104.49,115.48 R498.2 ; v1(110.53,55.66) 110.53,54.9 108.88,53.25 v1(108.88,36.11) ; v1(121.07,36.04) 121.58,35.53 121.58,31.6 J19.14
VDIG1: length 305.4
  TOP w0.635: v1(126.97,141.77) 126.97,141.45 FB21.2
  TOP w0.762: v1(112.05,50.08) 111.61,49.63 99.48,49.63 99.09,49.25 88.24,49.25 87.54,48.55 81.57,48.55 80.78,49.34 73.04,49.34 72.59,49.79 72.26,50.12 70.8,50.12 70.26,50.65 70.05,50.65 69.95,50.76 66.4,50.76 65.66,50.02 59.78,50.02 59.47,50.33 53.84,50.33 v1(53.82,50.35) ; v1(52.87,97) v1(56.53,97) ; J19.11 121.46,34.78 110.79,34.78 v1(110.53,34.52) ; v1(96.33,23.96) v1(103.92,23.96) ; v1(127.04,130.97) 101,130.97 v1(99.48,132.5)
  LY3 w0.762: v1(99.48,132.5) 97.52,130.54 92.29,130.54 91.55,129.81 87.19,129.81 86.4,130.59 84.75,130.59 84.37,130.21 81.98,130.21 81.49,130.69 75.91,130.69 75.55,130.34 v1(53.12,130.34)
  BOTTOM w0.635: v1(126.97,141.77) 126.97,131.04 v1(127.04,130.97)
  BOTTOM w0.762: v1(53.12,130.34) 53.12,124.47 57.07,120.53 57.07,117.92 56.53,117.39 v1(56.53,97) 56.53,95.23 56.17,94.87 56.17,91.71 56.53,91.35 56.53,87.13 57.14,86.52 57.14,85.58 57.49,85.23 57.49,82.51 57.49,82.5 57.49,82.07 57.24,81.83 FB1.2 56.23,80.72 55.59,80.07 53.91,80.07 52.23,78.4 52.23,74.84 55.28,71.79 55.28,59.47 54.84,59.03 54.78,59.03 53.82,58.07 v1(53.82,50.35) ; FB3.2 128.12,130.97 v1(127.04,130.97) ; v1(112.05,50.08) R472.2 111.17,48.82 110.53,48.17 v1(110.53,34.52) 110.53,28.61 107.86,25.95 106.33,25.95 105.12,24.74 105.12,24.73 104.35,23.96 v1(103.92,23.96) ; v1(52.87,97) 52.72,96.85 52.72,96.2 51.57,95.06 51.57,94.12 FB7.2 ; R464.1 94.49,25.81 v1(96.33,23.96)
VDIG2: length 275.4
  TOP w0.635: v1(104.91,62.49) 109.16,62.49 v1(109.19,62.46) v1(111.8,62.46) ; v1(106.78,30.77) 111.42,30.77 114.4,33.75 122.97,33.75 J19.12 ; v1(103.92,25.18) 93.08,25.18 92.32,25.95 92.31,25.95 92.26,26 91.73,26 91.36,26.37 R476.1 ; v1(52.28,53.63) v1(63.6,53.63) 64.09,53.14 64.26,53.14 65.18,52.22 70.76,52.22 71.38,51.6 71.94,51.6 72.6,50.94 73.38,50.17 81.35,50.17 82.02,49.5 87.16,49.5 87.73,50.07 98.65,50.07 99.03,50.46 106.46,50.46 106.97,50.96 v1(108.18,50.96) ; R497.1 98.14,115.73 98.46,116.05 98.46,119.67 98.08,120.05 92.54,120.05 v1(91.02,118.52) ; v1(50.2,100.11) v1(52.74,100.11)
  LY3 w0.635: v1(91.02,118.52) 83.2,118.52 81.29,120.43 76.54,120.43 74.38,118.27 v1(53.12,118.27)
  BOTTOM w0.635: v1(50.2,100.11) 49.72,100.59 R500.1 ; R507.1 62.8,55.03 63.6,54.23 v1(63.6,53.63) ; v1(109.19,62.46) 109.19,57.82 108.18,56.81 v1(108.18,50.96) 108.18,47.47 107.23,46.52 107.23,31.22 v1(106.78,30.77) 106.78,28.04 v1(103.92,25.18) ; R503.2 v1(104.91,62.49) ; v1(52.28,53.63) 52.28,62.19 52.93,62.84 52.93,67.66 50.46,70.14 46.06,70.14 43.7,72.5 43.7,78.35 45.73,80.38 45.73,92.05 48.55,94.88 R499.1 49.92,94.88 50.74,95.69 50.8,95.69 51.89,96.79 51.89,97.19 52.74,98.04 v1(52.74,100.11) v1(52.74,106.46) 52.74,107.16 53.12,107.54 v1(53.12,118.27) ; v1(111.8,62.46) 111.8,63.44 R506.2
VETH_AVDD_3_3: length 10.5
  TOP w0.203: U25.16 v1(32.18,51.27)
  TOP w0.508: v1(27.6,49.06) 27.07,48.54 FB15.2
  BOTTOM w0.508: FB15.2 27.6,48.31 v1(27.6,49.06) 27.6,49.44 28.31,50.15 31.05,50.15 32.12,51.22 32.14,51.22 v1(32.18,51.27) 32.42,51.5 C194.1
VETH_LX:
  vias: v1(28.87,59.09)
VETH_VDDIO: length 5.7
  TOP w0.203: U25.29 v1(37.09,54.56)
  BOTTOM w0.635: v1(37.09,54.56) 36.99,54.65 C193.1
  BOTTOM w0.762: R407.1 v1(25.95,59.98) ; R389.2 R388.1 v1(25.56,52.62) ; R408.2 29.63,61 28.99,60.36 v1(28.99,60.11)
VMMC: length 289.9
  TOP w0.508: v1(121.45,98.14) 120.37,97.07 v1(115.42,97.07) ; R477.1 81.69,27.85 v1(80.68,27.85) ; v1(93.89,20.99) 97.19,20.99 99.16,22.96 104.05,22.96 104.94,23.85 104.94,24.68 106.46,26.2 112.94,26.2 120.69,18.45 v1(121.7,18.45) ; v1(125.89,53.5) 129.39,53.5 131.8,55.92 151.24,55.92 152.21,54.95 157.95,54.95 v1(158.91,55.92) ; v1(123.48,134.47) v1(128.5,134.47) 130.78,134.47 130.97,134.28 157.33,134.28 v1(157.39,134.21)
  BOTTOM w0.508: v1(125.89,53.5) 125.64,53.5 124.88,52.74 124.88,33.12 J19.13 124.94,30.77 124.94,26.07 124.56,25.69 123.1,25.69 121.96,24.55 121.96,18.71 v1(121.7,18.45) ; v1(93.89,20.99) 93.89,22.64 92.62,23.91 85.13,23.91 84.75,24.29 80.56,24.29 79.67,25.18 79.67,27.22 80.3,27.85 v1(80.68,27.85) ; v1(158.91,55.92) 158.91,56.83 159.03,56.95 159.03,96.69 157.39,98.34 v1(157.39,134.21) ; FB4.2 128.5,134.46 v1(128.5,134.47) ; v1(121.45,98.14) 121.45,108.75 120.37,109.83 120.37,110.91 121.39,111.92 121.39,118.91 120.56,119.73 120.56,129.2 123.48,132.12 v1(123.48,134.47)
  BOTTOM w0.635: FB5.2 v1(115.42,97.07)
VPLL: length 131.1
  TOP w0.508: J19.15 122.66,27.98 v1(108.75,27.98) ; v1(54.58,54.39) 63.99,54.39 65.47,52.92 71.05,52.92 71.67,52.3 72.23,52.3 72.64,51.89 72.89,51.64 73.67,50.87 81.86,50.87 82.46,50.27 86.84,50.27 87.35,50.77 98.33,50.77 98.72,51.15 106.17,51.15 106.68,51.66 109.45,51.66 v1(109.51,51.73) ; R473.2 v1(109.51,37.88)
  BOTTOM w0.121: v1(109.51,51.73) 109.51,51.47
  BOTTOM w0.508: v1(108.75,27.98) 108.75,34.9 109.51,35.66 v1(109.51,37.88) 109.51,51.47 ; FB9.2 56.04,76.68 56.04,59.16 55.15,58.27 55.09,58.27 54.58,57.76 v1(54.58,54.39)
VPMIC_VRTC: length 6.4
  TOP w0.203: 90.74,38.21 90.64,38.11 90.26,38.11 90.05,37.9 U4.29
  TOP w0.381: 90.74,38.21 v1(91.53,38.21)
  BOTTOM w0.508: v1(91.53,38.21) 91.6,38.29 C97.1 R53.1 93.51,38.39 R60.2
VPP: length 0.6
  TOP w0.381: v2(87.4,81) U2.M5
VPWRIN_FUSED: length 2.7
  TOP w0.502: SW1.1 75.6,11.11 ; SW1.1 75.6,9.28 ; SW1.1 74.69,10.2
VPWRIN_JCK: length 8.7
  TOP w0.502: J1.1 55.79,17.33 ; J1.1 55.79,12.97 ; J1.1 53.61,15.15 ; J1.1 57.97,15.15
VREFP_ADC: length 15.6
  TOP w0.102: U2.B9 78.73,84.6 78.33,85 77.1,85
  TOP w0.121: 77.1,85 76.98,84.88 75.62,84.88 74.61,85.89 74.08,85.89 73.44,86.52 72.15,86.52 71.78,86.16 71.78,86.16 71.77,86.15 70.02,86.15 C10.1 C9.1 68.13,86.24 68.01,86.24 67.35,86.91 67.35,89.19
VRTC: length 195.3
  TOP w0.381: U33.6 59.08,104.62 59.04,104.66 C7.1 58.41,104.15 v1(58.1,103.85) ; v1(54.49,101.22) U1.1 U1.5
  TOP w0.508: v1(71.28,50.9) 71.09,50.9 70.58,51.42 70.37,51.42 70.26,51.52 66.08,51.52 65.65,51.09 v1(64.05,51.09) ; v1(61.19,59.28) 62.14,58.33 v1(63.66,58.33)
  TOP w0.635: v1(61.19,59.28) 61.19,60.4 60.54,61.05 60.54,64.68 57.03,68.19 41.18,68.19 35.77,62.78 v1(35.57,62.78) ; v1(120.05,41.31) 111.29,41.31 107.8,44.8 97.64,44.8 v1(94.14,41.31)
  LY3 w0.508: v1(54.49,101.22) 54.49,102.6 55.74,103.85 v1(58.1,103.85) 59.19,102.75 63.49,102.75 63.99,102.25 v1(63.99,101.56)
  BOTTOM w0.381: v1(54.49,101.22) 54.03,101.22 C1.1 ; R393.2 34.81,62.01 v1(35.57,62.78)
  BOTTOM w0.508: R54.2 83.6,37.06 v1(83.1,37.57) 82.32,38.34 80.48,38.34 78.43,40.39 78.43,40.52 77.76,41.19 77.76,45.88 77.38,46.27 77.38,49.44 75.92,50.9 v1(71.28,50.9) ; v1(94.14,41.31) C91.1 92.75,40.17 ; v1(61.19,59.28) 61.19,59.77 61.24,59.82 61.24,61.41 61.19,61.46 61.19,68.93 64.3,72.05 64.3,81.7 63.91,82.09 63.91,83.52 63.28,84.15 63.28,87.17 62.53,87.92 62.53,88.95 62.05,89.43 62.05,95.8 62.65,96.39 62.65,98.6 62.84,98.79 62.84,100.38 63.21,100.75 63.79,100.75 63.79,101.36 v1(63.99,101.56) ; v1(63.66,58.33) 63.66,56.74 64.31,56.1 64.31,52.81 64.05,52.55 v1(64.05,51.09) 63.47,50.52 61.22,50.52 R505.2
  BOTTOM w0.635: v1(120.05,41.31) 120.05,44.8 121.89,46.65 121.89,55.54 J19.3
  vias: v1(86.14,25.31) v1(86.14,24.55)
VUSB_VBUS0: length 96.5
  TOP w0.508: v1(96.43,100.62) 96.3,100.49 R563.1
  TOP w0.762: v1(137.51,160.57) C262.1 v1(136.33,159.38)
  LY3 w0.508: v1(133.51,152.37) v1(99.41,152.37)
  LY4 w0.508: v1(99.41,152.37) 99.41,152.06 98,150.65 98,135.85 96.54,134.39 96.54,129.27 96.05,128.78 96.05,122.91 98.18,120.78 98.18,117.17 97.4,116.38 97.4,109.61 96.43,108.65 v1(96.43,100.62)
  BOTTOM w0.502: J36.1 136.44,154.94 ; J36.1 135.39,153.9 ; J36.1 136.44,152.86 ; J36.1 137.48,153.9
  vias: v1(132.02,164.76) v1(132.88,164.76) v1(133.77,164.73) v1(134.15,151.61) v1(134.72,152.37) v1(135.48,151.61) v1(136.05,152.37)
VUSB_VBUS1: length 118.7
  TOP w0.502: J37.1 151.99,158.75 ; J37.1 150.95,157.71 ; J37.1 151.99,156.67 ; 148.46,165.01 J18.1 ; J18.1 150.44,165.01 ; J18.1 149.45,164.02 ; J18.1 149.45,166
  TOP w0.508: R564.1 90.59,105.96 v1(90.21,106.34)
  TOP w0.635: v1(145.16,159.19) C265.1 v1(144.06,160.44)
  LY3 w0.508: v1(88.99,150.79) 89.65,150.13 91.37,150.13 91.47,150.02 91.99,150.02 92.1,150.13 98.87,150.13 100.01,151.27 130.72,151.27 131.46,150.53 140.88,150.53 v1(141.77,151.42)
  LY4 w0.508: v1(90.21,106.34) 90.15,106.39 90.15,140.6 89.09,141.66 89.09,150.68 v1(88.99,150.79)
  BOTTOM w0.502: 149.45,163.89 J18.1 ; J18.1 150.57,165.01 ; J18.1 148.33,165.01 ; J18.1 149.45,166.13 ; J37.1 151.99,158.75 ; J37.1 153.03,157.71 ; J37.1 150.95,157.71 ; J37.1 151.99,156.67
  vias: v1(142.4,152.37) v1(143.1,151.42) v1(143.67,152.37) v1(144.37,151.42) v1(147.55,163.8) v1(148.31,163.87) v1(149.14,163.74)
N17759: length 6.1
  TOP w0.121: Y2.1 104.45,83.75 104.18,83.48 C5.1 100.95,83.48 R8.2 R7.1
N120395: length 1.7
  TOP w0.121: D3.2 84.09,18.18 R50.1
N124510: length 2.9
  TOP w0.121: v1(31.41,95.54) J2.4
  BOTTOM w0.121: R73.2 v1(31.41,95.54)
N150689: length 13.1
  TOP w0.121: Y1.1 61.76,78.78 61.76,77.13 62.86,76.02 C3.2 66.8,76.11 67.47,76.11 67.8,76.44 67.8,78.58 67.79,78.59 67.79,78.96 68.25,79.41 R5.2
N194366: length 15
  TOP w0.102: 77.1,84.6 U2.A9
  TOP w0.121: 77.1,84.6 77.07,84.63 75.52,84.63 74.51,85.64 73.95,85.64 73.32,86.27 72.24,86.27 71.89,85.91 71.88,85.91 71.87,85.9 70.54,85.9 70.14,85.51 70.14,85.25 C10.2 C9.2 67.96,85.41 67.7,85.41 67.35,85.76 67.35,83.48
N16794306: length 4.5
  TOP w0.121: R390.2 23.66,5.24 25.18,3.72 J15.D1
N16794816: length 7.5
  TOP w0.121: R392.2 44.61,2.51 43.79,1.69 J15.D4
N16958667: length 21.2
  TOP w0.121: U10.69 143.63,27.64 148.25,23.02 160.06,23.02 v1(160.82,22.26) R308.2
N17034041: length 2.7
  TOP w0.121: v1(153.96,69.13) SW3.1
  BOTTOM w0.121: R114.2 v1(153.96,69.13)
N17034069: length 2.7
  TOP w0.121: v1(153.96,66.59) SW3.2
  BOTTOM w0.121: R115.2 v1(153.96,66.59)
N17034107: length 2.7
  TOP w0.121: v1(153.96,64.05) SW3.3
  BOTTOM w0.121: R116.2 v1(153.96,64.05)
N17034117: length 2.7
  TOP w0.121: v1(153.96,61.51) SW3.4
  BOTTOM w0.121: R117.2 v1(153.96,61.51)
N17034161: length 2.7
  TOP w0.121: v1(153.96,58.97) SW3.5
  BOTTOM w0.121: R118.2 v1(153.96,58.97)
N17034171: length 2.7
  TOP w0.121: v1(153.96,56.43) SW3.6
  BOTTOM w0.121: R119.2 v1(153.96,56.43)
N17034215: length 2.7
  TOP w0.121: v1(153.96,53.89) SW3.7
  BOTTOM w0.121: R120.2 v1(153.96,53.89)
N17034225: length 2.7
  TOP w0.121: SW3.8 v1(153.96,51.35)
  BOTTOM w0.121: R121.2 v1(153.96,51.35)
N17059155: length 1.7
  TOP w0.121: U10.36 135.99,38.39 v1(135.86,38.52)
  BOTTOM w0.121: v1(135.86,38.52) 135.99,38.39 R325.2
N17084504: length 2.2
  TOP w0.121: R277.2 161.96,19.6 D8.1
N17084966: length 21.9
  TOP w0.121: U10.72 145.13,27.79 148.5,24.42 160.95,24.42 v1(163.11,22.26) R326.2
N17107785: length 3.6
  TOP w0.203: v1(94.04,35.01) 94.04,34.43 93.1,33.49 U4.18
  BOTTOM w0.381: v1(94.04,35.01) 94.4,34.66 C98.1
N17298950: length 2.2
  TOP w0.121: U18.6 C179.1
N17298952: length 5
  TOP w0.121: U18.2 108.47,21.75 108.72,22.01 108.72,24.19 108.55,24.37 107.78,24.37 C177.1
N17298960: length 2.5
  TOP w0.121: U18.3 105.83,20.48 C176.2
N17298962: length 2.2
  TOP w0.121: 104.94,19.09 105.07,19.21 U18.4
N17298964: length 2.2
  TOP w0.121: C178.2 105.07,17.94 U18.5
N17298974: length 2.4
  TOP w0.121: U18.1 105.57,23.02 C176.1
N17338171: length 71.8
  TOP w0.121: U16.4 32.23,130.78 34.75,128.26 42.09,120.92 66.19,120.92 66.39,121.13 v1(67.73,121.13) ; R354.2 74.46,98.34 v1(74.21,98.59)
  BOTTOM w0.121: v1(67.73,121.13) 67.73,120.33 71.12,116.94 71.12,103.54 71.11,103.53 71.11,102 74.21,98.91 v1(74.21,98.59)
N17338175: length 74.3
  TOP w0.121: U16.5 31.93,131.43 35,128.36 35.29,128.07 35.29,128.07 42.19,121.17 66.08,121.17 66.49,121.58 68.17,121.58 68.36,121.39 69.13,121.39 69.19,121.44 71.28,121.44 v1(71.28,121.45) ; v1(74.46,100.49) 75.09,99.86 75.86,99.86 R355.2
  BOTTOM w0.121: v1(71.28,121.45) 73.19,119.54 73.19,104.98 74.02,104.15 74.02,102.97 74.59,102.4 74.59,100.62 v1(74.46,100.49)
N17338916: length 70.7
  TOP w0.121: U16.6 31.63,132.08 42.27,121.44 42.54,121.44 65.88,121.44 66.27,121.82 68.74,121.82 v1(68.74,121.83) ; v1(73.19,101.26) R356.2
  BOTTOM w0.121: v1(73.19,101.26) 72.56,101.26 71.6,102.21 71.6,103.32 71.62,103.33 71.62,117.38 68.74,120.26 v1(68.74,121.83)
N17338919: length 71.2
  TOP w0.121: U16.7 31.33,132.73 42.37,121.69 65.75,121.69 66.33,122.27 71.22,122.27 v1(72.05,121.45) ; R357.2 v1(74.46,103.16)
  BOTTOM w0.121: v1(72.05,121.45) 73.57,119.93 73.57,104.95 74.46,104.06 v1(74.46,103.16)
N17339217: length 2.5
  TOP w0.121: R347.2 28.16,125.08 U14.5
N17339337: length 29.1
  TOP w0.121: v1(37.53,130.47) 37.91,130.09 37.91,129.02 39.18,127.75 45.4,127.75 45.86,127.29 R348.2 ; U14.6 27.85,125.73 27.85,125.76 27.98,125.89 v1(34.43,125.89)
  BOTTOM w0.121: v1(37.53,130.47) 36.56,130.47 34.43,128.33 v1(34.43,125.89)
N17339991: length 72.8
  TOP w0.121: v1(86.14,123.06) 84.2,123.06 84.03,123.23 80.86,123.23 79.93,122.3 75.06,122.3 73.25,120.5 68.55,120.5 68.24,120.18 38.09,120.18 34.28,123.99 27.98,123.99 27.54,124.43 U14.4 ; R346.2 85.51,131.74 v1(85.89,131.36)
  BOTTOM w0.121: v1(85.89,131.36) 86.08,131.36 86.59,130.84 86.59,124.02 86.14,123.58 v1(86.14,123.06)
N17340025: length 56.8
  TOP w0.121: R335.2 80.68,122.59 80.14,122.05 75.19,122.05 73.27,120.13 71.82,120.13 71.23,119.54 70.33,119.54 70.2,119.67 29.56,119.67 29.27,119.38 U13.6
N17340083: length 62.7
  TOP w0.121: R336.2 v1(72.68,104.05) ; v1(71.09,120.05) 70.54,120.05 70.35,120.24 68.68,120.24 68.36,119.93 28.69,119.93 28.59,120.03 U13.7
  BOTTOM w0.121: v1(72.68,104.05) 72.68,104.56 71.87,105.37 71.87,118.71 71.09,119.48 v1(71.09,120.05)
N17342017: length 126.3
  TOP w0.121: v1(112.31,125.51) 103.29,125.51 102.65,126.15 99.22,126.15 98.08,125.01 94.4,125.01 93.39,124 89.48,124 89,123.52 86.66,123.52 86.43,123.75 78.73,123.75 78.02,123.04 74.69,123.04 74.37,122.72 74,122.72 73.38,123.35 70.72,123.35 69.9,122.53 66.39,122.53 66.38,122.52 66.23,122.52 65.75,122.04 61.61,122.04 61.51,121.93 42.48,121.93 31.1,133.31 31.1,133.68 27.66,137.13 U15.4 ; v1(112.31,154.22) 112.31,155.23 112.69,155.61 R350.2
  BOTTOM w0.121: v1(112.31,154.22) v1(112.31,125.51)
N17342025: length 68.2
  TOP w0.121: v1(59.35,122.44) 58.45,122.44 58.36,122.35 42.41,122.35 31.35,133.41 31.35,133.79 27.36,137.78 U15.5
  BOTTOM w0.121: R351.2 64.33,97.57 64.77,98.02 64.77,102.11 64.93,102.27 64.93,107.91 65.14,108.11 65.14,111.87 60.18,116.83 60.18,121.6 v1(59.35,122.44)
N17342093: length 37.9
  TOP w0.121: U15.7 28.26,139.08 28.75,138.58 28.75,137.08 31.6,134.24 31.6,133.51 42.14,122.97 v1(47.41,122.97) ; R352.2 v1(47.92,115.48)
  BOTTOM w0.121: v1(47.92,115.48) 47.92,122.47 v1(47.41,122.97)
N17345501: length 2.7
  TOP w0.121: v1(153.96,91.73) SW4.1
  BOTTOM w0.121: R122.2 v1(153.96,91.73)
N17345515: length 2.7
  TOP w0.121: v1(153.96,89.19) SW4.2
  BOTTOM w0.121: R123.2 v1(153.96,89.19)
N17345519: length 2.7
  TOP w0.121: v1(153.96,86.65) SW4.3
  BOTTOM w0.121: R124.2 v1(153.96,86.65)
N17345529: length 2.7
  TOP w0.121: v1(153.96,84.11) SW4.4
  BOTTOM w0.121: R125.2 v1(153.96,84.11)
N17345551: length 2.7
  TOP w0.121: v1(153.96,81.57) 155.61,81.57
  BOTTOM w0.121: R126.2 v1(153.96,81.57)
N17345553: length 2.7
  TOP w0.121: v1(153.96,79.03) SW4.6
  BOTTOM w0.121: R127.2 v1(153.96,79.03)
N17345567: length 2.7
  TOP w0.121: v1(153.96,76.49) SW4.7
  BOTTOM w0.121: R128.2 v1(153.96,76.49)
N17345577: length 2.7
  TOP w0.121: v1(153.96,73.95) SW4.8
  BOTTOM w0.121: R129.2 v1(153.96,73.95)
N17563948: length 183.4
  TOP w0.121: R509.1 98.59,155.74 v1(98.46,155.61) ; v1(74.41,154.19) 74.81,154.59 81.56,154.59 81.82,154.33 84.55,154.33 84.79,154.09 85.21,154.09 86.02,154.9 R85.1 86.27,155.61 v1(86.78,156.12) ; v1(40.5,116.32) 29.53,116.32 28.05,114.85 25.8,114.85 25.68,114.97 24.4,114.97 22.87,116.5 v1(22.86,116.5) ; Q1.G 10.44,88.54 R86.2 10.45,89.45 10.2,89.7 9.82,89.7 v1(9.31,90.21) ; v1(76.72,104.94) 76.72,104.66 R84.1
  LY3 w0.133: v1(40.5,116.32) 41.11,116.32 41.49,116.7 72.45,116.7 72.57,116.81 77.22,116.81 v1(77.53,116.5)
  BOTTOM w0.121: v1(76.72,104.94) 76.72,105.93 77.53,106.74 v1(77.53,116.5) 77.53,117.44 77.14,117.82 77.14,119.18 73.74,122.58 73.74,128.68 74.97,129.91 74.97,135.61 74.67,135.91 74.67,140.39 73.95,141.11 73.95,148.5 74.08,148.63 74.08,150.79 73.95,150.91 73.95,153.73 v1(74.41,154.19) ; v1(98.46,155.61) 98.84,155.99 98.84,160.25 97.96,161.13 89.31,161.13 88.87,160.69 88.87,158.22 v1(86.78,156.12) ; v1(9.31,90.21) 9.31,92.35 9.57,92.62 9.57,96.7 12.61,99.73 16.55,99.73 21.2,104.38 21.2,111.15 22.14,112.08 22.14,114.67 22.86,115.39 v1(22.86,116.5)

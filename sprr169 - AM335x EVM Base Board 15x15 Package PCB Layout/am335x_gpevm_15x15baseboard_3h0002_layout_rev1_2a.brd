# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_2a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_D23: length 69.2
  TOP w0.121: v1(148.12,30.77) 147.67,30.33 146.91,30.33 146.55,30.69 U10.4 ; v1(152.87,81.88) 152.53,82.21 143.42,82.21 143.09,81.89 142.48,81.89 142.18,81.59 R303.1
  BOTTOM w0.121: v1(148.12,30.77) 149.16,30.77 154.71,36.32 154.71,49.06 153.52,50.25 153.52,81.24 152.88,81.88 v1(152.87,81.88)
HDMI_DE: length 87.1
  TOP w0.121: v1(135.57,47.15) 135.03,47.69 134.29,47.69 134.16,47.56 134.16,47 134.03,46.87 131.99,46.87 131.86,46.75 131.86,46.42 131.99,46.29 134.03,46.29 134.16,46.16 134.16,45.92 134.03,45.79 131.37,45.79 131.25,45.92 131.25,46.62 131.12,46.75 124.81,46.75 124.68,46.87 124.68,47.28 124.81,47.41 v1(130.79,47.41) ; v1(125.77,74.33) 125.26,74.84 125.26,75.48 125.51,75.73 R312.1 ; U10.33 138.13,39.87 137.58,40.42 136.82,40.42 134.66,42.58 v1(134.66,43.47)
  BOTTOM w0.121: v1(125.77,74.33) 126.79,74.33 126.98,74.52 127.61,74.52 129.89,72.24 129.89,68.49 130.02,68.36 130.34,68.36 130.47,68.49 130.47,71.03 130.59,71.16 130.98,71.16 131.11,71.03 131.11,61.19 130.85,60.93 130.85,57.34 130.97,57.21 131.3,57.21 131.43,57.34 131.43,60.11 131.56,60.24 131.95,60.24 132.08,60.11 132.08,52.22 130.6,50.75 130.6,47.6 v1(130.79,47.41) ; v1(134.66,43.47) 134.66,43.91 135.41,44.66 136.41,44.66 136.54,44.79 136.54,48.3 136.41,48.42 135.7,48.42 135.57,48.3 v1(135.57,47.15)
HDMI_EXTSWING: length 1.8
  TOP w0.121: U10.56 137.13,29.19 v1(136.94,29.37)
  BOTTOM w0.381: R292.2 136.82,29.25 v1(136.94,29.37)
HDMI_HPLG: length 41.5
  TOP w0.121: U11.4 132.59,16.65 132.43,16.49 132.06,16.49 126.28,22.27 126.28,32.32 129.86,35.9 v1(130.75,35.9) ; v1(132.78,29.45) 132.78,29.02 132.73,28.97 R569.2 134.56,28.51 135.23,29.19 U10.54
  BOTTOM w0.121: v1(130.75,35.9) 130.75,35.06 131.46,34.35 131.46,30.77 v1(132.78,29.45)
HDMI_HSYNC: length 70.6
  TOP w0.121: v1(127.16,74.08) 126.66,74.59 R311.1 ; v1(133.51,43.47) 133.51,42.46 136.39,39.58 137.46,39.58 137.63,39.41 U10.34 ; v1(133.51,45.35) 131.25,45.35 v1(130.39,46.21)
  BOTTOM w0.121: v1(130.39,46.21) 130.35,46.25 130.35,61.01 130.85,61.51 130.85,67.98 130.72,68.11 130.34,68.11 130.21,67.98 130.21,61.76 130.09,61.63 129.7,61.63 129.58,61.76 129.58,72.05 129.45,72.17 129.2,72.17 129.07,72.05 129.07,67.09 128.94,66.97 128.56,66.97 128.43,67.09 128.43,72.05 128.31,72.17 127.29,72.17 127.16,72.3 127.16,72.68 127.29,72.81 128.46,72.81 128.59,72.94 128.59,73.19 128.46,73.32 127.29,73.32 127.16,73.44 v1(127.16,74.08) ; v1(133.51,45.35) v1(133.51,43.47)
HDMI_I2C_SCL: length 109.7
  TOP w0.121: R313.1 130.21,96 131.53,97.32 137.02,97.32 139.19,99.49 144.29,99.49 144.47,99.67 149.71,99.67 150.98,98.4 151.35,98.4 152.23,99.28 157.11,99.28 157.16,99.33 v1(158.36,99.33) ; U10.1 146.4,29.19 146.85,28.74 v1(148.37,28.74)
  BOTTOM w0.121: v1(158.36,99.33) 159.49,98.19 159.49,40.68 148.75,29.95 148.75,29.12 v1(148.37,28.74)
HDMI_I2C_SDA: length 191.4
  TOP w0.121: U10.2 146.41,29.69 146.85,29.25 148.91,29.25 v1(149.29,29.63) ; v1(60.11,94.21) 60.93,95.03 64.02,95.03 64.84,94.21 65.63,94.21 66.17,93.67 66.34,93.67 66.5,93.51 66.92,93.51 67,93.59 67.35,93.76 R314.1 ; v1(160.31,55.92) 159.87,56.36 158.69,56.36 157.79,55.46 152.77,55.46 151.87,56.36 132.76,56.36 130.85,58.26 128.84,58.26 128.77,58.33 123.22,58.33 122.03,57.14 120.59,57.14 117.15,53.7 100.22,53.7 100.16,53.76 98.46,53.76 97.29,52.59 86.18,52.59 85.76,52.17 83.67,52.17 83.15,52.68 74.42,52.68 74.05,53.05 72.96,54.15 72.55,54.55 72.55,55.15 72.29,55.41 71.93,55.41 71.26,54.74 66.4,54.74 66.38,54.75 64.2,56.93 61.4,56.93 58.9,59.43 v1(58.9,59.47)
  BOTTOM w0.121: v1(58.9,59.47) 58.9,69.16 61.52,71.78 62.62,72.87 62.62,80.97 62.23,81.35 62.23,81.41 62.21,81.44 62.21,82.85 61.57,83.48 61.57,86.39 60.85,87.11 60.85,88.11 59.71,89.25 59.71,91.97 59.8,92.06 59.8,93.32 60.11,93.63 v1(60.11,94.21) ; v1(160.31,55.92) 160.31,40.68 149.29,29.65 v1(149.29,29.63)
HDMI_I2CSCL: length 30.7
  TOP w0.121: U11.2 132.11,17.95 127.23,22.83 127.23,31.11 129.19,33.08 132.17,33.08 R567.1 133.67,32.55 134.53,31.69 U10.49
HDMI_I2CSDA: length 33
  TOP w0.121: U11.3 132.5,17.3 132.43,17.37 132.18,17.37 126.75,22.8 126.75,31.33 129.88,34.45 132.09,34.45 R568.1 133.21,33.84 134.86,32.19 U10.48
HDMI_INTN: length 149.8
  TOP w0.121: U10.52 135.92,30.2 134.61,30.2 134.51,30.29 v1(133.9,30.29) R570.1 ; R324.1 59.83,96.4 v1(59.55,96.12)
  LY3 w0.133: v1(63.89,48.09) 64.35,48.09 64.49,48.24 64.59,48.24 65.42,49.06 97.6,49.06 98.51,48.14 112.28,48.14 117.39,53.25 125.36,53.25 127.6,51.01 127.6,49.01 129.83,46.77 133.72,46.77 136.33,44.16 136.33,32.73 v1(133.9,30.29)
  LY4 w0.133: v1(63.89,48.09) 63.89,49.16 64.68,49.95 64.68,54.06 62.47,56.27 62.47,60.03 60.44,62.06 60.44,82.03 59.55,82.92 v1(59.55,96.12)
HDMI_IOVCC: length 34.3
  TOP w0.305: v1(147.1,29.76) 146.98,29.76 146.54,30.19 U10.3 ; U10.21 v1(144.13,39.23) ; v1(135.04,33.44) 135.29,33.19 U10.46
  TOP w0.508: FB12.1 v1(164.88,22.26) v1(164.88,23.41) ; v1(147.1,29.76) 147.99,29.76 v1(148.12,29.88)
  BOTTOM w0.508: v1(164.88,22.26) v1(164.88,23.41) 163.99,24.29 149.39,24.29 147.61,26.07 147.61,28.88 147.99,29.26 147.99,29.76 ; v1(144.13,39.23) 144.13,38.57 C152.1 ; C151.1 146.34,29.76 v1(147.1,29.76) 147.99,29.76 ; 147.99,29.76 v1(148.12,29.88) ; C150.1 135.29,33.69 v1(135.04,33.44)
HDMI_LSOE: length 4.2
  TOP w0.121: U11.5 136.35,16 v1(136.18,16.17)
  BOTTOM w0.121: R322.1 137.45,14.9 v1(136.18,16.17)
HDMI_PCLK: length 69.5
  TOP w0.121: v1(146.09,43.47) 146.09,40.6 145.27,39.79 143.9,39.79 143.63,39.52 U10.22 ; v1(144.94,48.92) 145.08,49.06 147.13,49.06 147.26,49.19 147.26,52.03 147.13,52.16 135.83,52.16 133.51,49.85 v1(131.04,49.85) ; v1(125.39,76.87) 125.89,76.87 126.02,76.75 R307.1
  BOTTOM w0.121: v1(125.39,76.87) 126.28,76.87 126.66,77.25 127.93,77.25 128.29,76.89 128.29,74.7 131.69,71.3 131.69,62.51 132.32,61.88 132.32,52.12 131.04,50.84 v1(131.04,49.85) ; v1(146.09,43.47) 146.09,46.14 144.49,47.74 144.49,48.47 v1(144.94,48.92)
HDMI_TX0+: length 27.6
  TOP w0.095: U10.62 140.13,27.87 140.02,27.76 140.02,24.18 138.7,22.86 138.7,21.51 139.86,20.35 139.86,16.8 142.15,14.51 142.37,14.51 142.55,14.7 U11.18 144.52,14.7 144.69,14.53 146.14,14.53 148.8,11.87 148.8,9.71 148.89,9.61 149.06,9.61 149.16,9.52 J10.7
HDMI_TX0-: length 27.6
  TOP w0.095: U10.61 139.63,27.87 139.74,27.76 139.74,24.3 138.42,22.97 138.42,21.4 139.58,20.23 139.58,16.69 142.04,14.23 142.37,14.23 142.55,14.05 U11.17 144.74,14.05 144.94,14.25 146.02,14.25 148.52,11.75 148.52,9.71 148.42,9.61 148.25,9.61 148.16,9.52 J10.9
HDMI_TX1+: length 27.6
  TOP w0.095: J10.4 150.66,9.52 150.56,9.61 150.39,9.61 150.3,9.71 150.3,11.79 145.63,16.46 144.55,16.46 144.37,16.65 U11.21 142.55,16.65 142.37,16.46 142.11,16.46 140.63,17.94 140.63,21.06 139.89,21.79 139.89,22.58 141.52,24.21 141.52,27.76 141.63,27.87 U10.65
HDMI_TX1-: length 27.6
  TOP w0.095: J10.6 149.66,9.52 149.75,9.61 149.92,9.61 150.02,9.71 150.02,11.68 145.51,16.18 144.55,16.18 144.37,16 U11.20 142.55,16 142.37,16.18 141.99,16.18 140.35,17.83 140.35,20.94 139.61,21.68 139.61,22.69 141.24,24.32 141.24,27.76 141.13,27.87 U10.64
HDMI_TX2+: length 27.6
  TOP w0.095: U10.68 143.13,27.87 143.02,27.76 143.02,23.4 141.34,21.72 141.34,18.5 142.08,17.76 142.37,17.76 142.55,17.95 U11.23 144.37,17.95 144.55,17.76 145.65,17.76 151.8,11.61 151.8,9.71 151.89,9.61 152.06,9.61 152.16,9.52 J10.1
HDMI_TX2-: length 27.6
  TOP w0.095: U10.67 142.63,27.87 142.74,27.76 142.74,23.51 141.06,21.83 141.06,18.38 141.96,17.48 142.37,17.48 142.55,17.3 U11.22 144.37,17.3 144.55,17.48 145.53,17.48 151.52,11.5 151.52,9.71 151.42,9.61 151.25,9.61 151.16,9.52 J10.3
HDMI_VSYNC: length 70.3
  TOP w0.121: v1(142.02,46.27) 141.26,46.27 141.07,46.46 138.44,46.46 138.31,46.33 138.31,44.61 138.19,44.49 137.65,44.49 137.53,44.61 137.53,46.33 137.4,46.46 136.86,46.46 136.74,46.34 136.74,44.86 136.62,44.74 136.38,44.74 136.26,44.86 136.26,46.34 136.14,46.46 135.89,46.46 135.77,46.34 135.77,44.86 135.65,44.74 135.41,44.74 135.29,44.86 135.29,46.34 135.17,46.46 134.54,46.46 134.41,46.33 134.41,44.99 133.07,43.65 133.07,41.51 135.26,39.33 136.71,39.33 137.13,38.92 U10.35 ; R305.1 141.92,74.94 141.92,73.9 142.05,73.77 142.79,73.77 142.91,73.9 142.91,75.02 143.04,75.14 143.79,75.14 143.92,75.02 143.92,73.9 144.04,73.77 144.82,73.77 144.94,73.9 144.94,74.87 145.07,74.99 146.19,74.99 146.37,74.81 v1(146.37,74.31)
  BOTTOM w0.121: v1(142.02,46.27) 142.02,54.35 142.11,54.44 145.55,54.44 145.94,54.83 145.94,72.25 146.37,72.68 v1(146.37,74.31)
HDMICONN_CEC: length 12.1
  TOP w0.121: U11.7 138.54,14.7 141.64,11.59 142.02,11.59 142.91,10.7 144.49,10.7 144.61,10.58 145.45,10.58 146.16,9.87 J10.13
HDMICONN_HPLG: length 9.5
  TOP w0.121: J10.19 142.86,8.42 142.66,8.22 v1(142.2,8.22) 140.75,9.66 140.75,10.83 138.84,12.75 U11.10
  BOTTOM w0.121: R304.2 v1(142.2,8.22)
HDMICONN_I2CSCL: length 13.7
  TOP w0.121: U11.8 138.68,14.05 141.44,11.29 141.95,11.29 142.78,10.45 144.38,10.45 145.16,9.68 J10.15 145.16,6.48 v1(145.38,6.26)
  BOTTOM w0.121: v1(145.38,6.26) R276.1
HDMICONN_I2CSDA: length 13
  TOP w0.121: v1(144.66,6.23) J10.16 144.66,9.59 144.05,10.21 143.47,10.21 143.47,10.2 142.66,10.2 141.87,10.98 141.24,10.98 138.85,13.37 138.51,13.37 138.49,13.4 U11.9
  BOTTOM w0.121: v1(144.66,6.23) 144.11,5.68 R275.1
JTAG_EMU0: length 68.4
  TOP w0.102: v2(79.4,89) U2.C14
  TOP w0.121: v1(34.73,91.69) 35.17,91.69 35.37,91.5 47.08,91.5 48.45,92.86 56.14,92.86 57.23,93.95 59.28,93.95 59.91,93.32 60.94,93.32 62.14,94.53 63.83,94.53 64.67,93.69 65.46,93.69 65.96,93.18 66.14,93.18 66.31,93 67.75,93 68.52,92.23 69.98,92.23 70.3,92.55 v1(70.3,92.68) ; v1(22.14,89.19) J2.13
  LY3 w0.133: v1(34.73,91.69) 31.95,91.69 30.16,93.48 25.49,93.48 24.98,92.98 24.98,92.04 v1(22.14,89.19)
  BOTTOM w0.102: 78.98,89 v2(79.4,89)
  BOTTOM w0.121: v1(70.3,92.68) 70.3,92.38 73.46,89.23 78.75,89.23 78.98,89 ; R71.1 v1(22.14,89.19)
JTAG_EMU1: length 62.4
  TOP w0.102: 77.1,89.4 77.5,89 78.6,89 U2.B14
  TOP w0.121: v1(31.91,93.76) 32.57,93.76 32.88,93.46 32.88,92.85 33.35,92.38 47.14,92.38 48.11,93.36 55.92,93.36 57.31,94.75 59.45,94.75 60.23,95.53 62.36,95.53 63.08,96.26 65.33,96.26 65.68,96.61 69.05,96.61 v1(69.35,96.3) ; v1(73.06,91.75) 73.07,91.75 73.46,91.36 73.46,90.78 73.6,90.64 74.98,90.64 75.96,89.66 76.84,89.66 77.1,89.4 ; J2.14 v1(31.41,89.19)
  BOTTOM w0.121: R70.1 v1(31.41,89.19) 31.91,89.7 v1(31.91,93.76) ; v1(73.06,91.75) 71.9,91.75 70.99,92.66 70.99,93.25 69.61,94.63 69.61,95.41 69.35,95.67 v1(69.35,96.3)
JTAG_TCK: length 60.4
  TOP w0.102: U2.A12 77.75,87 77.1,87.65
  TOP w0.121: v1(63.66,89) 59.85,89 59.1,89.75 56.26,89.75 54.69,91.31 49.03,91.31 47.32,89.6 35.5,89.6 35.3,89.39 v1(34.86,89.39) ; v1(65.12,90.84) 65.51,90.84 65.63,90.72 67.94,90.72 69.26,89.4 69.49,89.4 69.49,89.39 73.33,89.39 74.4,89.39 74.62,89.17 75.37,88.42 76.33,88.42 77.1,87.65
  LY3 w0.133: v1(25.95,90.46) 30.44,90.46 31,89.9 34.35,89.9 v1(34.86,89.39)
  BOTTOM w0.121: v1(63.66,89) 63.98,89 65.12,90.14 v1(65.12,90.84) ; v1(25.95,90.46) R75.2 R74.2
JTAG_TDI: length 71.9
  TOP w0.102: 77.1,87.12 77.63,86.59 78.61,86.59 U2.B11
  TOP w0.121: J2.3 26.07,95.54 26.45,95.92 26.45,97.32 26.71,97.57 32.02,97.57 32.04,97.6 v1(34.15,97.6) ; v1(71.02,87.84) 71.33,88.15 71.39,88.15 72.26,89.02 73.49,89.02 74.24,89.02 75.22,88.05 75.22,88.05 76.17,88.05 77.1,87.12 ; v1(63.66,88.11) 59.41,88.11 58.81,88.71 56.38,88.71 54.4,90.69 49.29,90.69 47.57,88.98 40.44,88.98 39.37,87.91 34.22,87.91 v1(33.9,88.23)
  BOTTOM w0.121: v1(33.9,88.23) 33.9,88.67 33.84,88.73 33.84,97.29 v1(34.15,97.6) ; v1(63.66,88.11) 64.13,88.58 66.97,88.58 68.69,86.85 70.23,86.85 71.02,87.64 v1(71.02,87.84)
JTAG_TDO: length 60.2
  TOP w0.102: U2.A11 77.45,86.2 77.1,86.55
  TOP w0.121: J2.7 v1(25.95,93) ; v1(34.76,90.56) 35.2,90.56 35.42,90.34 47.01,90.34 48.72,92.05 55.52,92.05 56.92,90.65 61.56,90.65 61.63,90.72 63.39,90.72 64.03,90.08 65.14,90.08 65.14,90.08 65.27,90.08 65.64,90.45 67.85,90.45 69.16,89.15 69.69,89.15 70.58,88.26 70.58,87.58 70.76,87.4 71.27,87.4 72.37,88.5 72.52,88.64 73.64,88.64 74.09,88.64 75.07,87.67 75.98,87.67 77.1,86.55
  LY3 w0.133: v1(25.95,93) 30.06,93 32.5,90.56 v1(34.76,90.56)
JTAG_TMS: length 70.3
  TOP w0.102: v2(79.41,87.41) 79.41,86.59 U2.C11
  TOP w0.121: v1(69.19,99.92) 68.55,99.92 67.98,99.35 67.22,98.59 64.77,98.59 64.27,98.09 63.7,98.09 63.29,98.49 61.42,98.49 61.05,98.13 55.94,98.13 55.25,98.82 43.22,98.82 42.42,98.03 34.34,98.03 34.33,98.04 33.97,98.04 33.96,98.03 24.64,98.03 24,97.4 J2.1
  LY4 w0.121: v1(69.86,91.49) 69.89,91.49 70.9,92.5 70.9,93.58 68.87,95.6 68.87,99.61 v1(69.19,99.92)
  BOTTOM w0.102: v2(79.41,87.41) 78.59,87.41 77.52,88.48 77.1,88.48
  BOTTOM w0.121: 77.1,88.48 73.15,88.48 71.81,89.83 71.28,89.83 69.86,91.25 v1(69.86,91.49)
JTAG_TRSTN: length 63.2
  TOP w0.102: U2.B10 78.82,85.4 78.4,85.83 77.44,85.83 77.1,86.17
  TOP w0.121: v1(34.28,89.05) 34.59,88.74 39.63,88.74 40.24,89.35 47.42,89.35 49.13,91.06 54.56,91.06 56.18,89.45 58.65,89.45 59.53,88.56 63.48,88.56 63.48,88.56 63.85,88.56 64.3,89.02 v1(64.71,89.02) ; J2.2 v1(31.41,96.81) 32.28,96.81 32.29,96.82 32.66,96.82 32.67,96.81 v1(34.28,96.81) ; v1(70.14,87.87) 70.14,87.67 70.51,87.3 70.66,87.15 71.37,87.15 72.62,88.4 73.75,88.4 73.98,88.4 74.97,87.41 75.86,87.41 77.1,86.17
  BOTTOM w0.121: v1(34.28,96.81) 34.28,96.37 34.28,96.37 34.28,89.5 34.28,89.5 v1(34.28,89.05) ; v1(70.14,87.87) 70.13,87.87 68.92,87.87 67.78,89.02 v1(64.71,89.02) ; v1(31.41,96.81) R79.2
LCD_DATA0: length 4.5
  TOP w0.102: 138.01,85.25 J7.4
  TOP w0.121: R240.1 140.12,86.27 140.12,86.42 140.02,86.52 139.07,86.52 138.88,86.34 138.88,86.29 139.1,86.07 139.1,85.94 138.95,85.79 138.54,85.79 138.01,85.25
LCD_DATA1: length 4.7
  TOP w0.102: 138.04,85.91 136.59,85.91 J7.3
  TOP w0.121: 138.04,85.91 138.11,85.91 139.23,87.03 R241.1
LCD_DATA2: length 4.4
  TOP w0.102: J7.6 137.91,83.98 138.04,83.86
  TOP w0.121: 138.04,83.86 138.06,83.83 138.06,83.78 138.24,83.6 138.39,83.6 138.39,83.6 138.52,83.73 138.52,83.81 138.61,83.9 138.78,83.9 138.85,83.83 138.85,83.72 138.98,83.6 139.17,83.6 139.25,83.68 139.25,83.96 139.43,84.14 139.63,84.14 139.65,84.11 140.01,84.11 140.14,83.98 140.14,83.88 R245.1
LCD_DATA3: length 4.5
  TOP w0.121: R246.1 139.61,84.87 139.1,84.87 v1(138.72,84.49)
  BOTTOM w0.102: J7.5 136.54,84.59 137.93,84.59 138.04,84.49
  BOTTOM w0.121: v1(138.72,84.49) 138.04,84.49
LCD_DATA4: length 4.5
  TOP w0.102: J7.8 137.83,82.71 137.98,82.56 137.98,82.21 138.04,82.16
  TOP w0.121: 138.04,82.16 138.18,82.01 138.3,82.01 138.44,82.16 138.63,82.16 138.86,81.93 139,81.93 139.1,82.03 139.1,82.21 139.18,82.28 139.33,82.28 139.53,82.08 140.07,82.08 140.13,82.01 140.13,81.84 R251.1
LCD_DATA5: length 4.5
  TOP w0.121: R252.1 138.85,82.59 v1(138.59,82.84)
  BOTTOM w0.102: J7.7 136.56,83.35 137.96,83.35 138.04,83.27
  BOTTOM w0.121: v1(138.59,82.84) 138.47,82.84 138.04,83.27
LCD_DATA6: length 4.5
  TOP w0.102: J8.15 130.67,77.63 130.52,77.79 130.52,78.32
  TOP w0.121: R270.1 129.15,77.76 129.27,77.63 129.27,77.53 129.4,77.41 129.93,77.41 130.06,77.53 130.06,78.32 130.19,78.45 130.39,78.45 130.52,78.32
LCD_DATA7: length 8.6
  TOP w0.121: R259.1 129.2,82.84 v1(129.49,82.55)
  LY3 w0.102: 130.57,81.44 J8.9
  LY3 w0.133: 130.57,81.44 130.21,81.44 130.09,81.57 130.09,83.2 129.96,83.32 127.88,83.32 127.75,83.2 127.75,82.9 128.1,82.55 v1(129.49,82.55)
LCD_DATA8: length 9.4
  TOP w0.102: J8.11 131.53,80.17 132.19,80.83 133.49,80.83 133.59,80.94 ; 133.59,81.95 133.46,82.08 130.72,82.08
  TOP w0.121: R262.1 129.53,80.81 130.14,81.42 130.14,81.78 130.26,81.9 130.26,81.9 130.44,82.08 130.72,82.08 ; 133.59,80.94 133.64,80.94 133.84,81.14 133.84,81.83 133.72,81.95 133.59,81.95
LCD_DATA9: length 4.1
  TOP w0.102: J8.13 130.67,78.9 130.54,78.78 129.81,78.78 129.71,78.68 129.71,78.14 129.61,78.04 129.41,78.04 129.31,78.14 129.31,78.68 129.2,78.78 R266.1
LCD_DATA10: length 10.1
  TOP w0.121: v1(138.72,80.37) 139.18,79.91 139.18,79.67 139.31,79.54 R256.1
  LY3 w0.102: 138.14,81.32 138.01,81.44 J7.10
  LY3 w0.133: v1(138.72,80.37) 138.72,78.68 138.85,78.55 139.97,78.55 140.09,78.68 140.09,80.89 139.99,80.99 138.47,80.99 138.14,81.32
LCD_DATA11: length 10.7
  TOP w0.121: R267.1 139.1,77.13 v1(138.89,77.34)
  LY3 w0.102: 141.67,77.91 138.29,77.91 138.01,77.63 J7.16
  LY3 w0.133: 141.67,77.91 141.79,77.79 141.79,76.62 141.67,76.49 139.13,76.49 138.89,76.73 v1(138.89,77.34)
LCD_DATA12: length 13.1
  TOP w0.121: v1(138.59,81.57) 138.34,81.32 138.34,81.19 138.46,81.07 139.74,81.07 139.86,80.94 R257.1
  BOTTOM w0.102: 138.04,82.42 137.97,82.42 137.63,82.08 136.56,82.08 J7.9
  BOTTOM w0.121: v1(138.59,81.57) 139.31,81.57 139.51,81.77 139.51,84.62 139.41,84.72 139.27,84.72 139.18,84.62 139.18,82.21 139.05,82.08 138.29,82.08 138.21,82.16 138.21,82.3 138.09,82.42 138.04,82.42
LCD_DATA13: length 18.6
  TOP w0.121: v1(129.53,81.57) 129.27,81.83 R258.1
  LY3 w0.102: 133.59,80.83 130.99,80.83 130.72,80.57 ; J8.10 133.59,81.44
  LY3 w0.133: 133.59,81.44 133.67,81.52 133.67,84.45 133.79,84.57 133.96,84.57 134.08,84.45 134.08,84.21 134.23,84.06 134.4,84.06 134.53,83.93 134.53,83.11 134.4,82.98 134.28,82.98 134.15,82.85 134.15,82.57 134.28,82.45 134.43,82.45 134.56,82.32 134.56,82.04 134.43,81.91 134.2,81.91 134.07,81.79 134.07,81.51 134.2,81.38 134.38,81.38 134.5,81.25 134.5,80.96 134.38,80.83 133.59,80.83 ; v1(129.53,81.57) 128.94,82.16 128.54,82.16 128.41,82.02 128.41,81.93 129.37,80.97 130.13,80.97 130.26,80.83 130.26,80.7 130.4,80.57 130.72,80.57
LCD_DATA14: length 9.2
  TOP w0.102: 138.04,79.72 138.04,78.88 138.04,78.87 ; 138.04,80.17 J7.12
  TOP w0.121: R260.1 140.25,78.78 140.25,78.85 140.06,79.03 139.65,79.03 139.57,79.12 139.4,79.12 139.25,78.97 139.25,78.35 139.14,78.24 138.98,78.24 138.87,78.35 138.87,79.72 138.75,79.84 138.57,79.84 138.44,79.72 138.44,78.44 138.33,78.32 138.16,78.32 138.04,78.44 138.04,78.87 ; 138.04,80.17 138.16,80.05 138.16,79.84 138.04,79.72
LCD_DATA15: length 24.4
  TOP w0.121: R254.1 v1(129.7,83.86)
  LY3 w0.102: J8.7 130.65,82.71 130.55,82.82
  LY3 w0.133: v1(129.7,83.86) 127.14,83.86 127.01,83.98 127.01,85.41 127.14,85.55 129.82,85.55 129.96,85.68 129.96,85.95 129.82,86.08 127.14,86.08 127.01,86.21 127.01,86.47 127.14,86.6 127.4,86.6 127.65,86.85 127.93,86.85 128.19,86.6 130.29,86.6 130.42,86.47 130.42,85.29 130.28,85.15 128.29,85.15 128.15,85.02 128.15,84.75 128.29,84.62 130.28,84.62 130.42,84.49 130.42,82.95 130.55,82.82
LCD_DATA16: length 64.1
  TOP w0.121: R253.1 97.53,93.41 98.36,93.41 98.64,93.69 98.64,94.62 100.06,96.04 103.21,96.04 104.99,97.82 113.7,97.82 114.03,98.16 115.17,98.16 115.29,98.28 115.29,99.49 115.41,99.61 115.65,99.61 115.77,99.49 115.77,99.32 115.89,99.2 119.3,99.2 119.42,99.08 119.42,98.84 119.3,98.72 115.89,98.72 115.77,98.6 115.77,98.28 115.89,98.16 v1(116.34,98.16)
  LY4 w0.133: v1(117,86.38) 117,86.96 116.78,87.18 116.78,93.84 116.79,93.86 116.79,94.43 116.47,94.75 116.47,95.62 116.34,95.75 115.79,95.75 115.66,95.88 115.66,96.15 115.79,96.28 116.34,96.28 116.47,96.42 116.47,98.03 v1(116.34,98.16)
  BOTTOM w0.102: J8.8 132.7,82.71 132.09,82.1 130.77,82.1 130.72,82.16
  BOTTOM w0.121: v1(117,86.38) 117.26,86.63 126.85,86.63 127.14,86.35 127.14,84.34 127.7,83.78 129.1,83.78 130.72,82.16
LCD_DATA17: length 46.1
  TOP w0.121: R248.1 103.27,94.27 104.79,95.79 117.25,95.79 117.54,96.07 v1(118.41,96.07)
  LY4 w0.133: v1(118.02,87.46) 118.02,89.56 118.41,89.95 118.41,93.51 118.54,93.64 119.54,93.64 119.67,93.78 119.67,94.04 119.54,94.18 118.54,94.18 118.41,94.31 118.41,94.58 118.54,94.71 119.54,94.71 119.67,94.84 119.67,95.11 119.54,95.24 118.54,95.24 118.41,95.38 v1(118.41,96.07)
  BOTTOM w0.102: J8.5 131.28,83.98 130.72,84.54 130.72,84.75
  BOTTOM w0.121: 130.72,84.75 130.34,85.13 130.03,85.13 127.7,87.46 119.71,87.46 119.52,87.28 119.16,87.28 118.97,87.46 v1(118.02,87.46)
LCD_DATA18: length 53.5
  TOP w0.102: J8.6 132.12,83.35 130.85,83.35 130.72,83.48
  TOP w0.121: R247.1 97.51,88.86 97.52,88.87 97.9,88.87 98,88.78 98.79,88.78 98.92,88.9 v1(98.92,89.04) ; v1(106.78,88.24) 106.78,87.26 108.11,85.93 108.11,83.4 109.55,81.96 112.77,81.96 114.37,83.56 122.4,83.56 122.68,83.84 122.85,83.84 123.19,83.5 123.36,83.5 123.53,83.67 123.53,83.84 123.19,84.18 123.19,84.35 123.36,84.52 123.53,84.52 123.87,84.19 124.04,84.19 124.21,84.36 124.21,84.53 123.87,84.86 123.87,85.03 124.04,85.21 124.21,85.21 124.55,84.87 124.72,84.87 124.89,85.04 124.89,85.21 124.55,85.55 124.55,85.72 124.72,85.89 124.9,85.89 125.23,85.55 125.4,85.55 125.57,85.72 125.57,85.89 125.24,86.23 125.24,86.4 126,87.16 127.55,87.16 127.67,87.03 127.67,86.3 127.55,86.18 126.17,86.18 126.05,86.06 126.05,85.81 126.17,85.69 127.55,85.69 127.67,85.57 127.67,85.25 128.48,84.45 129.75,84.45 130.72,83.48
  BOTTOM w0.121: v1(106.78,88.24) 106.77,88.24 105.71,88.24 104.91,89.04 v1(98.92,89.04)
LCD_DATA19: length 30.1
  TOP w0.121: v1(118.77,85.29) 118.33,85.29 117.68,85.94 117.19,85.94 117.19,85.94 116.82,85.94 116.82,85.94 115.18,85.94 115,86.12 112.41,86.12 R264.1
  LY3 w0.102: 130.63,79.96 131.03,79.56 133.16,79.56 133.82,78.9 J7.13
  LY3 w0.133: v1(118.77,85.29) 120.22,85.29 122.06,87.13 125.34,87.13 126.55,85.91 126.55,83.25 129.09,80.71 129.88,80.71 130.63,79.96
LCD_DATA20: length 26.6
  TOP w0.102: 130.72,85.25 J8.3
  TOP w0.121: R243.1 112.48,82.71 112.84,83.07 112.84,83.36 112.72,83.48 112.48,83.48 112.36,83.6 112.36,83.93 112.48,84.05 122.19,84.05 125.8,87.67 127.93,87.67 128.18,87.41 128.18,85.52 128.75,84.95 130.28,84.95 130.59,85.25 130.72,85.25
LCD_DATA21: length 35.6
  TOP w0.102: 130.72,85.89 132.12,85.89 J8.4
  TOP w0.121: 130.72,85.89 130.02,85.19 128.96,85.19 128.43,85.73 128.43,87.52 128.31,87.64 128.31,87.67 128.06,87.92 125.7,87.92 122.09,84.3 114.34,84.3 113.96,84.69 113.96,84.9 114.08,85.03 117.21,85.03 117.33,85.15 117.33,85.57 117.21,85.69 116.72,85.69 116.72,85.69 112.74,85.69 112.3,85.26 111.84,85.26 111.34,85.76 R242.1
LCD_DATA22: length 52.5
  TOP w0.121: R263.1 v1(104.81,91.6)
  LY3 w0.133: v1(137.36,91.12) 139.08,91.12 139.56,90.63 139.56,90.28 139.83,90.01 139.85,90.01 139.85,89.96 v1(140.17,89.65)
  BOTTOM w0.102: 138.04,78.9 J7.14
  BOTTOM w0.121: v1(137.36,91.12) 136.97,91.12 136.18,90.33 132.49,90.33 131.9,90.92 131.86,90.92 131.07,91.71 130.05,91.71 129.12,90.77 128.68,90.33 125.3,90.33 124.73,90.91 108.62,90.91 107.92,91.6 v1(104.81,91.6) ; 138.04,78.9 139,78.9 140.8,80.7 140.8,88.91 140.48,89.22 140.48,89.34 v1(140.17,89.65)
LCD_DATA23: length 44.4
  TOP w0.121: v1(128.89,87.59) 128.13,88.35 128.13,88.48 128.01,88.6 120.22,88.6 v1(119.34,87.72) ; R261.1 108.77,91.6 110.3,93.13 114.92,93.13 115.05,93 118.12,93 118.53,93.41 v1(119.98,93.41)
  LY3 w0.102: v1(128.89,87.59) 129.6,87.59 129.64,87.63 129.74,87.63 129.78,87.67 130.14,87.67 130.21,87.59 130.54,87.59 130.72,87.41 133.92,87.41 134.81,86.52 134.81,85.36 135.04,85.13 135.04,80.25 135.11,80.17 J7.11
  LY4 w0.133: v1(119.98,93.41) 119.34,92.77 v1(119.34,87.72)
LCD_DEN: length 20.6
  TOP w0.102: v1(130.01,76.36) 129.32,76.36 R273.1
  BOTTOM w0.102: 130.72,75.71 133.44,75.71 133.57,75.58 133.57,75.14 ; J8.17 130.72,76.36 ; 130.72,77 130.73,76.99 133.53,76.99 133.59,77.05 ; 133.59,77.33 133.59,77.36 133.72,77.48 133.72,77.99
  BOTTOM w0.121: 133.57,75.14 133.7,75.02 134.08,75.02 134.25,75.19 134.25,77.99 134.12,78.12 133.84,78.12 133.72,77.99 ; 130.72,75.71 130.54,75.71 130.42,75.84 130.42,76.24 130.54,76.36 130.72,76.36 ; v1(130.01,76.36) 130.01,79.16 130.14,79.29 130.39,79.29 130.52,79.16 130.52,77.12 130.64,77 130.72,77 ; 133.59,77.33 133.59,77.05
LCD_HSYNC: length 6
  TOP w0.102: 130.72,75.7 132.09,75.7 J8.18
  TOP w0.121: 130.72,75.7 130.62,75.7 130.45,75.54 130.09,75.54 129.96,75.41 129.96,75.18 130.09,75.06 130.16,75.06 130.29,74.93 130.29,74.58 130.16,74.46 129.55,74.46 129.3,74.71 R272.1
LCD_I2C_SCL: length 19.6
  TOP w0.102: 133.59,78.07 J8.14
  TOP w0.121: 146.85,71.79 146.85,72.55 146.09,73.32 140.06,73.32 139.01,74.37 138.44,74.37 138.29,74.23 135.95,74.23 134,74.23 133.59,74.64 133.59,78.07
LCD_I2C_SDA: length 17.1
  TOP w0.102: 138.34,77 136.56,77 J7.15
  TOP w0.121: 138.34,77 138.72,76.62 142.02,76.62 142.99,75.65 146.44,75.65 147.23,74.87 147.23,73.67 147.35,73.55 147.35,71.03 146.85,70.52
LCD_PCLK: length 4.4
  TOP w0.102: 130.72,77 131.99,77 132.63,77.63 J8.16
  TOP w0.121: R269.1 128.94,77 130.72,77
LCD_VSYNC: length 4.5
  TOP w0.102: J7.17 136.59,75.7 138.04,75.7
  TOP w0.121: 138.04,75.7 138.77,74.97 R271.1
LCDA_PIN18: length 2.8
  TOP w0.102: 138.04,76.36 J7.18
  TOP w0.121: 138.04,76.36 138.47,76.36 138.85,75.98 R274.2
MCASP0_ACLKR: length 27
  TOP w0.121: R218.1 v1(70.62,107.48)
  BOTTOM w0.121: v1(70.62,107.48) 70.62,108.13 70.82,108.32 70.82,116.79 67.26,120.34 67.21,120.34 67.22,120.35 J6.17
MCASP0_ACLKX: length 7.1
  TOP w0.121: R194.2 87.54,131.53 v1(87.84,131.23)
  BOTTOM w0.121: v1(87.84,131.23) 88.49,130.58 88.49,126.59 J6.1
MCASP0_AHCLKR: length 45.2
  TOP w0.121: v1(70.52,155.59) 71.02,155.09 81.68,155.09 82.21,155.61 R211.2
  BOTTOM w0.121: J6.13 72.3,126.68 71.2,127.78 71.2,135.19 70,136.4 70,140.46 70.16,140.63 70.16,147.87 69.89,148.14 69.89,151.55 70.16,151.82 70.16,155.23 v1(70.52,155.59)
MCASP0_AHCLKX: length 20.9
  TOP w0.121: J6.27 v1(45.5,125.64) ; R234.1 v1(45.17,114.59)
  BOTTOM w0.121: v1(45.5,125.64) 45.5,119.75 45.17,119.42 v1(45.17,114.59)
MCASP0_AXR0: length 1.8
  BOTTOM w0.121: R203.2 J6.7
MCASP0_AXR1: length 8.4
  TOP w0.121: J6.23 58.46,125.64 57.43,126.66 52.48,126.66 R227.1
MCASP0_FSR: length 31.2
  TOP w0.121: v1(73.44,103.03) 73.7,102.78 R224.1 ; J6.21 62.97,124.81 63.83,124.81 64.78,123.86 v1(68.36,123.86)
  BOTTOM w0.121: v1(73.44,103.03) 73.44,104.38 72.86,104.96 72.86,119.18 70.27,121.77 69.57,121.77 68.79,122.54 68.79,123.43 v1(68.36,123.86)
MCASP0_FSX: length 1.8
  BOTTOM w0.121: R199.2 J6.5
MMC2_CLK: length 39.9
  TOP w0.121: v1(4.61,108.11) 7.64,108.11 7.76,107.99 7.76,107.58 7.64,107.45 4.74,107.45 4.61,107.33 4.61,106.94 4.89,106.66 21.76,106.66 U28.13
  BOTTOM w0.121: v1(4.61,108.11) 4.61,108.42 4.74,108.55 5.55,108.55 5.68,108.42 5.68,107.45 5.8,107.33 7.81,107.33 7.94,107.2 7.94,106.72 7.81,106.59 3.97,106.59 3.85,106.72 3.85,110.53 4.1,110.78 4.74,110.78 5.12,111.16 R485.1
MMC2_CMD: length 40.1
  TOP w0.121: v1(4.36,113.45) 3.87,113.45 3.75,113.58 3.75,115.43 3.62,115.56 2.96,115.56 2.83,115.43 2.83,110.27 3.59,109.51 3.59,109 3.85,108.75 4.49,108.75 4.62,108.88 4.62,109 4.74,109.13 7.89,109.13 8.01,109 8.01,107.04 8.14,106.91 16.8,106.91 16.93,107.04 16.93,107.3 16.8,107.43 13.63,107.43 13.5,107.56 13.5,107.83 13.63,107.96 17.61,107.96 17.74,107.83 17.74,107.04 17.87,106.91 19.98,106.91 20.44,107.37 U28.12
  BOTTOM w0.121: R486.1 v1(4.36,113.45)
MMC2_D0: length 40.6
  TOP w0.121: U28.14 22.27,105.64 21.98,105.35 20.81,105.35 19.74,106.42 4.78,106.42 2.58,108.62 2.58,119.26 2.7,119.39 3.24,119.39 3.36,119.26 3.36,116.12 3.49,115.99 3.79,115.99 3.91,116.12 3.91,116.75 4.04,116.88 v1(4.36,116.88)
  BOTTOM w0.121: R487.1 5.12,115.73 4.99,115.86 4.99,116.24 v1(4.36,116.88)
MMC2_D1: length 39.8
  TOP w0.121: v1(4.48,119.16) 4.48,118.53 4.36,118.4 3.8,118.4 3.67,118.53 3.67,119.7 3.54,119.82 2.45,119.82 2.32,119.7 2.32,108.5 4.65,106.17 19.45,106.17 20.55,105.07 22.52,105.07 22.77,105.32 U28.15
  BOTTOM w0.121: R488.1 v1(4.48,119.16)
MMC2_D2: length 39.5
  TOP w0.121: U28.8 20.47,109.37 19.87,109.97 v1(19.26,109.97) ; v1(18.63,105.7) 18.41,105.92 4.52,105.92 2.07,108.37 2.07,119.9 2.48,120.31 v1(4.48,120.31)
  BOTTOM w0.121: v1(18.63,105.7) 18.63,108.22 19.26,108.85 v1(19.26,109.97) ; R489.1 v1(4.48,120.31)
MMC2_D3: length 40.5
  TOP w0.121: v1(19.34,105.65) 19.34,105.62 18.98,105.26 18.41,105.26 17.99,105.67 4.38,105.67 1.82,108.24 1.82,120.56 v1(4.36,123.1) ; v1(19.34,107.86) 19.85,108.37 U28.10
  BOTTOM w0.121: v1(4.36,123.1) 5.12,123.1 R490.1 ; v1(19.34,107.86) v1(19.34,105.65)
MMC2_SDIO_SEL: length 3.4
  TOP w0.121: R515.1 R516.2 26.31,109.87 U28.24
MMC_CD: length 71.8
  TOP w0.121: J13.15 64.3,146.44 64.76,145.99 64.76,144.21 64.63,144.08 64.28,144.08 U21.3 64.14,144.18 R378.1 v1(62.27,144.18) ; v1(66.55,92.3) 66.55,92.3 67.75,92.3 69.02,91.03 69.97,91.03 70.36,90.64 71.79,90.64 72.3,91.15 R380.1
  BOTTOM w0.121: v1(62.27,144.18) 63.28,144.18 64.43,143.04 64.43,138.98 63.92,138.47 63.16,138.47 62.46,137.77 62.46,136.68 62.52,136.62 62.52,135.55 60.94,133.97 60.94,123.03 66.21,117.76 66.21,105.92 66.91,105.22 66.91,102.2 66.91,101.59 66.4,101.09 66.4,98.31 66.39,98.3 66.39,92.94 66.56,92.77 66.56,92.31 v1(66.55,92.3)
MMC_CLK: length 42.1
  TOP w0.121: v1(83.53,145.25) 83.21,144.94 82.36,144.94 81.81,144.39 81.8,144.39 81.3,143.89 77.82,143.89 77.61,143.68 72.03,143.68 71.82,143.89 66.54,143.89 65.23,142.58 61.07,142.58 60.29,141.79 57.7,141.79 57.57,141.92 57.57,142.8 57.71,142.94 U19.1 56.68,143.42 56.37,143.72 J13.5 56.3,148.58 56.3,149.78 56.18,149.9 53.15,149.9 53.03,149.78 J13.20
  BOTTOM w0.121: R398.1 83.6,145.17 v1(83.53,145.25)
MMC_CMD: length 51.3
  TOP w0.121: v1(55.41,150.85) 55.34,150.79 49.6,150.79 48.88,150.06 J13.2 48.73,148.35 48.73,147.28 v1(48.55,147.1) ; v1(58.97,145.58) 58.71,145.32 U19.7 ; J13.17 v1(59.73,147.11)
  LY3 w0.133: v1(80.78,145.55) 74.59,145.55 73.95,146.19 64.76,146.19 64.08,145.51 62.97,145.51 62.8,145.68 59.65,145.68 59.55,145.58 v1(58.97,145.58)
  BOTTOM w0.121: v1(80.78,145.55) 81.19,145.15 R397.1 ; R366.1 v1(48.55,147.1) ; v1(55.41,150.85) 55.41,150.79 55.54,150.66 56.68,150.66 56.81,150.53 56.81,150.28 56.93,150.16 59.48,150.16 60.36,151.04 61.51,151.04 61.63,150.91 61.63,148.75 61.51,148.63 59.85,148.63 J13.17 v1(59.73,147.11) 58.97,146.35 v1(58.97,145.58)
MMC_D0: length 47.7
  TOP w0.121: v1(61.38,147.1) 61.38,148.42 J13.7 61.12,148.68 61.12,149.77 61,149.9 56.67,149.9 56.43,150.14 50.96,150.14 50.53,149.71 J13.22 50.68,148.34 50.68,147.26 v1(50.84,147.1) ; v1(77.99,145.1) 77.99,144.41 77.51,143.93 72.13,143.93 71.93,144.13 66.44,144.13 65.14,142.84 60.77,142.84 60.03,142.1 58.44,142.1 v1(58.01,142.53) 58.01,142.84 58.13,142.96 58.13,143.34 U19.2
  BOTTOM w0.121: v1(77.99,145.1) 78.02,145.1 R399.1 ; v1(61.38,147.1) 61.38,146.57 60.95,146.14 60.69,146.14 59.37,144.82 58.58,144.82 58.32,144.55 58.32,142.84 v1(58.01,142.53) ; v1(50.84,147.1) R367.1
MMC_D1: length 42.2
  TOP w0.121: v1(49.69,147.1) 49.69,148.47 J13.23 49.72,150.01 50.1,150.39 56.56,150.39 56.81,150.15 62.87,150.15 63,150.02 J13.8 63,146.95 61.89,145.83 61.89,145.21 60.31,143.63 60.31,142.86 59.88,142.43 58.94,142.43 v1(58.8,142.57) 58.71,142.66 U19.3
  LY3 w0.133: v1(58.8,142.57) 65.35,142.57 66.68,143.89 69.73,143.89 v1(71.03,145.2)
  BOTTOM w0.121: R368.1 v1(49.69,147.1) ; R400.1 v1(71.03,145.2)
MMC_D2: length 42.7
  TOP w0.121: J13.24 v1(62.15,147.1) 62.15,146.86 v1(60.18,144.89) 59.98,144.69 U19.6 ; v1(43.85,147.1) 43.85,148.48 J13.9 43.88,149.79 44.42,150.34 46.45,150.34 47.66,151.54 57.7,151.54 v1(58.33,150.91)
  LY3 w0.133: v1(68.49,145.07) 67.63,144.21 66.51,144.21 66.44,144.14 63.3,144.14 62.55,144.89 v1(60.18,144.89)
  BOTTOM w0.121: v1(62.15,147.1) 62.15,151.28 61.51,151.93 59.35,151.93 v1(58.33,150.91) ; R401.1 v1(68.49,145.07) ; R369.1 v1(43.85,147.1)
MMC_D3: length 41.8
  TOP w0.121: v1(46.38,147.12) J13.1 46.45,148.58 46.45,149.83 47.92,151.29 57.06,151.29 v1(57.44,150.91) ; U19.8 v1(58.21,145.45) 58.21,145.96 58.58,146.34 60.17,146.34 60.52,146.69 v1(60.52,147.13) J13.16
  LY3 w0.133: v1(66.97,145.2) 66.1,145.2 65.42,144.51 63.44,144.51 62.61,145.34 60,145.34 59.79,145.13 58.78,145.13 58.52,145.13 v1(58.21,145.45)
  BOTTOM w0.121: R365.1 46.38,147.85 v1(46.38,147.12) ; v1(57.44,150.91) 57.44,150.78 57.82,150.4 59.34,150.4 59.6,150.66 59.6,151.42 59.85,151.68 61.25,151.68 61.89,151.04 61.89,148.5 v1(60.52,147.13) ; R396.1 v1(66.97,145.2)
MMC_D4: length 49.4
  TOP w0.121: v1(47.6,164.25) J13.10 47.6,167.62 48.3,168.31 63.54,168.31 64.81,167.04 64.81,163.61 65.19,163.23 v1(72.17,163.23) ; U20.1 72.71,148.87 72.71,148.6 v1(72.94,148.37)
  BOTTOM w0.121: v1(47.6,164.25) 47.6,165.2 R370.1 ; v1(72.17,163.23) 72.17,152.95 72.55,152.56 72.55,148.75 v1(72.94,148.37)
MMC_D5: length 45.6
  TOP w0.121: U20.2 v1(73.32,149.52) ; v1(50.12,164.25) 50.12,165.48 J13.11 50.1,167.45 50.58,167.93 63.16,167.93 64.3,166.79 64.3,163.36 64.93,162.72 v1(73.06,162.72)
  BOTTOM w0.121: v1(73.06,162.72) 73.06,150.53 73.32,150.28 v1(73.32,149.52) ; R371.1 50.12,165.21 v1(50.12,164.25)
MMC_D6: length 34.4
  TOP w0.121: v1(70.52,150.15) 70.65,150.02 U20.7 ; v1(57.6,164.31) J13.12 57.6,166.44 57.57,166.47 57.57,166.79 57.95,167.17 62.52,167.17 63.28,166.41 63.28,162.85 63.98,162.15 v1(71.16,162.15)
  BOTTOM w0.121: v1(70.52,150.15) 70.52,154.34 71.16,154.98 v1(71.16,162.15) ; v1(57.6,164.31) 57.6,165.23 R372.1
MMC_D7: length 32
  TOP w0.121: v1(60.11,164.38) 60.11,165.49 J13.13 60.1,166.44 60.2,166.53 62.39,166.53 62.9,166.03 62.9,162.72 63.92,161.71 69.89,161.71 70.14,161.45 v1(71.67,161.45) ; v1(70.52,149.39) 70.65,149.52 U20.8
  BOTTOM w0.121: v1(70.52,149.39) 70.96,149.83 70.96,154.02 71.67,154.72 v1(71.67,161.45) ; R373.1 v1(60.11,164.38)
MMC_WP: length 58.1
  TOP w0.121: J13.14 v1(65.5,145.58) 65.5,145.17 U21.5 ; R379.1 76.02,106.46 75.77,106.71 70.77,106.71 70.01,105.96 v1(67.22,105.96)
  BOTTOM w0.121: v1(67.22,105.96) 66.71,106.47 66.71,118.33 63.48,121.55 63.43,121.55 62.39,122.59 62.39,124.55 63.09,125.25 63.09,126.03 62.53,126.59 62.39,126.59 61.19,127.79 61.19,128.57 61.24,128.63 61.24,129.19 61.89,129.84 61.89,133.85 64.67,136.63 64.67,144.75 v1(65.5,145.58)
MVRK_GPIO1_D0: length 6.4
  TOP w0.121: R437.1 114.34,161.07 J16.2
MVRK_GPIO1_D1: length 75.9
  TOP w0.121: v1(104.94,155.1) 104.94,155.31 104.05,156.2 104.05,163.61 104.3,163.87 109,163.87 J16.4
  LY4 w0.133: v1(104.94,155.1) 105.59,154.45 105.59,123.86 104.25,122.52 104.25,119.85 104.56,119.54 104.56,114.92 102.27,112.64 v1(102.27,110.08)
  BOTTOM w0.121: v1(102.27,110.08) 103.21,109.14 103.21,101.71 103.75,101.18 103.75,98.02 103.87,97.89 R439.1
MVRK_GPIO1_D2: length 72.8
  TOP w0.121: J16.6 107.86,163.36 107.61,163.61 104.81,163.61 104.43,163.24 104.43,157.13 105.57,155.99 105.57,154.98 v1(104.94,154.34)
  LY4 w0.133: v1(104.94,154.34) 105.14,154.14 105.14,124.42 101.8,121.08 101.8,115.92 101.45,115.57 v1(101.45,110.08)
  BOTTOM w0.121: v1(101.45,110.08) 102.47,109.06 102.47,99.03 102.78,98.72 R440.1
MVRK_GPIO1_D3: length 67.4
  TOP w0.121: J16.8 106.24,161.55 106.24,154.31 v1(106.21,154.28)
  LY4 w0.133: v1(106.21,154.28) 105.85,153.92 105.85,123.46 104.59,122.19 104.59,120.05 104.89,119.75 104.89,114.36 103.1,112.57 v1(103.1,110.08)
  BOTTOM w0.121: R441.1 105.32,99.36 105.23,99.45 105.23,100.27 103.86,101.64 103.86,103.53 103.54,103.85 103.54,109.64 v1(103.1,110.08)
MVRK_GPIO1_D4: length 6.6
  TOP w0.121: R442.1 102.91,157.54 101.89,158.56 101.89,161.58 J16.10
MVRK_GPIO1_D5: length 6.4
  TOP w0.121: R444.1 100.37,157.67 101.13,158.43 101.13,161.58 J16.12
MVRK_GPIO1_D6: length 6.5
  TOP w0.121: R446.1 97.45,157.82 96.66,158.61 96.66,161.43 J16.14
MVRK_GPIO1_D7: length 6.1
  TOP w0.121: R447.1 94.27,156.76 94.27,161.58 J16.16
MVRK_GPIO1_LATCHEN: length 6.5
  TOP w0.121: R450.1 90.08,157.06 89.17,157.97 89.17,161.56 J16.20
MVRK_I2C_SCL: length 93.2
  TOP w0.121: v1(73.57,159.83) 75.14,159.83 79.44,164.12 98.64,164.12 99.35,163.41 99.35,160.82 J16.11 ; v1(75.66,102.27) 76.24,101.7 R443.2
  BOTTOM w0.121: v1(75.66,102.27) 75.82,102.43 75.82,103.07 75.66,103.23 75.66,119.81 75.05,120.43 75.05,120.52 73.25,122.32 73.25,122.53 73.25,128.75 71.45,130.55 71.45,135.63 71.98,136.16 71.98,139.96 73.58,141.56 73.58,148.75 73.76,148.93 73.76,150.36 73.58,150.53 73.58,155.45 73.57,155.46 v1(73.57,159.83)
MVRK_I2C_SDA: length 91.4
  TOP w0.121: J16.13 98.82,161.05 98.82,163.16 98.26,163.71 79.64,163.71 75.17,159.24 v1(69.81,159.24) ; R445.2 v1(75.22,105.96)
  BOTTOM w0.121: v1(75.22,105.96) 74.95,106.23 74.95,120.17 74.8,120.32 74.8,120.42 70.96,124.26 70.96,134.86 69.75,136.06 69.75,140.57 69.92,140.73 69.92,147.74 69.63,148.02 69.63,151.68 69.92,151.96 69.92,155.49 69.81,155.59 v1(69.81,159.24)
MVRK_SPI_CS: length 3.3
  TOP w0.121: R452.2 J16.23
MVRK_SPI_SCLK: length 34
  TOP w0.121: R448.2 87.1,130.97 v1(87.35,130.72)
  BOTTOM w0.121: J16.17 92.62,156.53 87.22,151.13 87.22,148.87 85.28,146.93 85.28,135.7 87.22,133.76 87.22,131.34 87.35,131.21 v1(87.35,130.72)
MVRK_SPI_SIMO: length 3.2
  TOP w0.121: R451.2 J16.21
MVRK_SPI_SOMI: length 54.9
  TOP w0.121: v1(94.91,123.68) 94.51,123.29 89.75,123.29 89.05,122.59 R449.2
  BOTTOM w0.121: v1(94.91,123.68) 94.91,123.73 95.03,123.86 95.03,128.11 95.48,128.55 95.48,130.84 95.03,131.29 95.03,132.69 95.1,132.76 95.1,132.78 95.16,132.84 95.16,133.08 95.66,133.58 95.66,134.21 95.4,134.46 95.4,134.74 95.16,134.98 95.16,135.86 95.19,135.89 95.34,136.04 95.34,143.45 95.53,143.64 95.53,144.21 95.16,144.58 95.16,147.99 93.46,149.69 93.46,158.46 93.79,158.79 93.79,160.41 93.32,160.88 91.03,160.88 J16.19
MVRK_UART_RXD: length 120.9
  TOP w0.121: J16.3 111.67,161.2 111.67,163.36 110.58,164.45 79.29,164.45 75.14,160.31 69.15,160.31 v1(68.03,159.19) ; v1(73.76,94.27) R438.2
  BOTTOM w0.121: v1(73.76,94.27) 73.76,94.59 73.44,94.91 73.44,99.32 70.84,101.92 70.84,103.61 70.87,103.64 70.87,105.99 70.18,106.68 70.18,111.01 70.57,111.4 70.57,116.55 66.33,120.79 66.33,123.28 66.12,123.49 66.12,132.77 66.97,133.62 66.97,134.44 67.29,134.76 67.29,140.92 67.74,141.37 67.74,146.1 68.11,146.47 68.11,152.18 68.33,152.4 68.33,156.26 68.03,156.56 v1(68.03,159.19)
MVRK_UART_TXD: length 56.1
  TOP w0.121: v1(113.42,149.14) 113.06,149.14 112.61,148.69 97.25,148.69 94.45,145.9 93.27,145.9 93.08,145.71 v1(82.76,145.71) ; R436.2 v1(81.95,134.28)
  BOTTOM w0.121: v1(81.95,134.28) 81.95,135.42 82.46,135.93 82.46,144.66 82.76,144.96 v1(82.76,145.71) ; v1(113.42,149.14) 113.42,152.59 112.94,153.07 J16.1
NAND_ADVN_ALE: length 12.2
  TOP w0.121: U9.17 151.26,97.78 149.61,99.42 144.61,99.42 144.18,99 142.14,99 141.48,98.34 R137.1
NAND_BE0N_CLE: length 11.4
  TOP w0.121: U9.16 150.76,95.93 150.63,95.8 148.12,95.8 147.54,95.22 147.54,95.16 147.29,94.91 143.29,94.91 142.4,95.8 R136.1
NAND_CSN: length 9
  TOP w0.121: U9.9 147.26,95.5 v1(147.1,95.35) 147.04,95.29 143.42,95.29 141.64,97.07 R135.1
  BOTTOM w0.121: R132.1 v1(147.1,95.35)
NAND_D0: length 19.5
  TOP w0.121: U9.29 152.76,109.51 150.1,106.84 R140.1
NAND_D1: length 18.3
  TOP w0.121: R141.1 150.66,108.24 152.26,109.84 U9.30
NAND_D2: length 16.6
  TOP w0.121: R142.1 150.53,109.64 151.76,110.87 U9.31
NAND_D3: length 14.7
  TOP w0.121: U9.32 151.26,112.4 149.77,110.91 R143.1
NAND_D4: length 9
  TOP w0.121: U9.41 146.76,113.49 145.83,112.56 141.52,112.56 R144.1
NAND_D5: length 7.2
  TOP w0.121: U9.42 146.26,114.64 145.2,113.58 R145.1
NAND_D6: length 7
  TOP w0.121: U9.43 145.76,114.65 145.07,113.96 142.15,113.96 R146.1
NAND_D7: length 6.6
  TOP w0.121: R147.1 141.18,116.19 141.18,115.68 142.53,114.34 144.31,114.34 145.26,115.29 U9.44
NAND_D8: length 75.5
  TOP w0.121: v1(124.24,94.4) 124.06,94.22 117.36,94.22 116.74,93.6 115.86,93.6 115.53,93.93 107.29,93.93 107,93.64 R148.1 ; U9.26 154.26,118.4 152.36,120.3 143.16,120.3 v1(140.12,117.26)
  BOTTOM w0.121: v1(140.12,117.26) 140.12,114.21 139.17,113.26 139.17,104.94 138.85,104.62 138.85,102.86 136.19,100.2 135.69,100.2 134.7,99.22 134.7,98.16 135.17,97.7 136.05,97.7 136.94,96.81 136.94,96.18 135.93,95.16 133.64,95.16 133.32,94.84 132.43,94.84 131.99,94.4 129.39,94.4 128.94,94.84 124.69,94.84 v1(124.24,94.4)
NAND_D9: length 70.3
  TOP w0.121: v1(154.09,115.1) 153.76,115.43 U9.27 ; v1(154.09,99.88) 154.09,99.89 153.41,100.57 144.17,100.57 143.86,100.26 138.91,100.26 136.74,98.08 131.24,98.08 128.68,95.52 127.44,95.52 127.19,95.27 124.14,95.27 123.4,94.53 106.34,94.53 105.91,94.95 105.11,94.95 104.69,94.53 104.69,94.27 R149.1
  BOTTOM w0.121: v1(154.09,115.1) v1(154.09,99.88)
NAND_D10: length 71
  TOP w0.121: v1(153.96,93) 153.07,93 151.74,91.67 150.79,91.67 149.68,90.56 144.72,90.56 143.31,89.15 132.45,89.15 131.49,90.11 129.95,90.11 128.99,89.15 117.2,89.15 116.86,88.82 110.53,88.82 R150.1 ; U9.28 v1(153.26,115.16)
  BOTTOM w0.121: v1(153.26,115.16) 153.26,98.63 153.96,97.93 v1(153.96,93)
NAND_D11: length 79.1
  TOP w0.102: 135.17,84.64 137.96,84.64 138.04,84.72 ; 133.59,84.64 130.82,84.64 130.77,84.7
  TOP w0.121: v1(150.25,85.99) 149.95,85.7 142.48,85.7 142.29,85.51 138.82,85.51 138.04,84.72 ; R151.1 109.64,82.45 109.88,82.21 112.49,82.21 114.08,83.81 122.29,83.81 125.89,87.41 127.65,87.41 127.93,87.13 127.93,85.38 128.61,84.7 130.77,84.7 ; 135.17,84.64 134.75,85.06 134.01,85.06 133.59,84.64 ; U9.33 v1(150.76,115.12)
  BOTTOM w0.121: v1(150.76,115.12) 150.76,108.34 149.31,106.89 149.31,98.98 150.17,98.13 150.17,93.22 149.44,92.49 149.44,87.92 149.92,87.44 149.92,87.43 150,87.36 150.25,87.1 v1(150.25,85.99)
NAND_D12: length 64.8
  TOP w0.121: v1(147.69,114.92) 147.26,115.35 U9.40 ; R152.1 112.83,88.57 116.96,88.57 117.3,88.91 129.09,88.91 130.05,89.86 131.39,89.86 132.35,88.91 143.69,88.91 144.87,90.08 v1(148.12,90.08)
  BOTTOM w0.121: v1(148.12,90.08) 148.12,93.76 147.64,94.25 147.64,98.92 148.12,99.4 148.12,114.34 147.69,114.77 v1(147.69,114.92)
NAND_D13: length 73.4
  TOP w0.121: R153.1 97.42,90.54 100.88,90.54 100.88,90.54 103.37,90.54 103.44,90.6 106.41,90.6 106.42,90.61 108.54,90.61 108.55,90.6 115.33,90.6 117.24,92.51 128.67,92.51 129.45,91.73 131.99,91.73 132.49,92.24 137.34,92.24 138.29,93.18 140.93,93.18 v1(141.13,93.38) ; v1(141.96,115.53) 142.52,114.97 144.56,114.97 144.76,115.17 U9.45
  BOTTOM w0.121: v1(141.96,115.53) 141.78,115.35 141.78,102.23 140.85,101.3 140.85,99.08 141.54,98.4 141.54,94.26 141.58,94.22 141.58,93.82 v1(141.13,93.38)
NAND_D14: length 66.6
  TOP w0.121: U9.46 v1(144.26,117.46) ; v1(143.74,101) 143.25,100.51 138.69,100.51 138.52,100.68 136.92,100.68 136.37,100.13 132.27,100.13 129.72,97.58 124.37,97.58 123.11,98.84 120.05,98.84 118.78,97.57 105.1,97.57 103.32,95.79 100.16,95.79 99.35,94.98 R154.1
  BOTTOM w0.121: v1(143.74,101) 143.79,101.05 143.79,117 v1(144.26,117.46)
NAND_D15: length 66.2
  TOP w0.121: v1(137.07,102.15) 136.82,102.4 136.82,102.41 136.57,102.65 132.8,102.65 130.3,100.15 130.01,99.86 114.49,99.86 112.97,98.34 104.34,98.34 102.55,96.55 98.63,96.55 R155.1 ; U9.47 143.76,117.68 143.52,117.92 142.33,117.92 141.23,116.82 139.36,116.82 v1(138.92,117.26)
  BOTTOM w0.121: v1(137.07,102.15) 137.07,102.52 138.35,103.8 138.35,104.94 138.67,105.26 138.67,117.01 v1(138.92,117.26)
NAND_OEN: length 14.3
  TOP w0.121: R134.1 v1(147.57,104.18) ; v1(147.03,98.08) 146.76,97.81 U9.8
  BOTTOM w0.121: v1(147.03,98.08) 147.03,98.94 147.81,99.73 147.81,103.93 v1(147.57,104.18)
NAND_WAIT: length 13.9
  TOP w0.121: v1(146.26,98.08) 146.25,97.91 U9.7 ; v1(147.37,102.98) 144.72,102.98 144.51,102.78 R133.1
  BOTTOM w0.121: v1(147.37,102.98) 147.37,100 146.65,99.27 146.65,98.46 v1(146.26,98.08) 146.6,97.75 R131.1
NAND_WEN: length 18.6
  TOP w0.121: R138.1 147.71,105.57 147.76,105.62 v1(150.07,105.62) ; U9.18 151.75,98 v1(151.68,98.08)
  BOTTOM w0.121: v1(150.07,105.62) 150.93,104.77 150.93,101.29 151.95,100.27 151.95,98.36 v1(151.68,98.08)
NAND_WPN: length 17.7
  TOP w0.121: v1(151.4,101.74) 151.4,101.13 151.27,101 148.02,101 147,102.02 141.65,102.02 R139.1 ; U9.19 152.25,97.9 v1(152.44,98.08)
  BOTTOM w0.121: R130.1 v1(152.44,98.08) 152.44,100.7 v1(151.4,101.74)
Net_833: length 0.7
  TOP w0.121: v1(132.5,163.38) 132.37,163.21 132.37,162.76
PB_INTERRUPT: length 5.7
  BOTTOM w0.121: C118.1 6.9,42.86 6.92,42.89 R156.1 6.92,45.76 6.9,45.78 R113.2 7.02,46.39 R560.1
PHY_LED_10/100N: length 1.6
  TOP w0.121: U25.26 v1(37.1,53.36)
  BOTTOM w0.381: C207.1 36.95,53.5 v1(37.1,53.36)
PHY_LED_1000N: length 52.2
  TOP w0.121: U25.24 36.77,52.08 38.77,50.08 v1(38.77,49.44) C206.1 ; v1(44.61,7.28) R392.1
  BOTTOM w0.121: v1(38.77,49.44) C206.1 39.23,48.55 45.5,42.28 45.5,8.17 v1(44.61,7.28)
PHY_LED_ACTN: length 67.5
  TOP w0.121: U25.23 34.98,51.58 35.22,51.35 36.36,51.35 37.63,50.08 37.63,49.57 v1(37.5,49.44) C205.1 ; R390.1 22.92,6.23 v1(23.63,6.23)
  BOTTOM w0.121: v1(23.63,6.23) 24.65,6.23 27.55,9.13 38.98,9.13 43.62,13.78 43.62,41.41 38.09,46.95 38.09,48.09 37.63,48.55 C205.1 v1(37.5,49.44)
PHY_PPS/GPIO: length 2.6
  TOP w0.121: v1(34.62,51.23) 34.62,51.35 34.58,51.38 U25.22
  BOTTOM w0.121: v1(34.62,51.23) 34.62,51.35 34.58,51.39 34.58,52.11 34.84,52.36 R395.1
PM_ALERT: length 21.6
  TOP w0.121: U32.3 63.47,35.15 63.92,35.6 63.92,36.3 v1(65.89,38.26)
  BOTTOM w0.121: U27.3 70.9,47.03 70.65,46.77 70.65,44.87 69.63,43.85 69.63,42.46 69.25,42.07 67.22,42.07 J17.4 R455.1 65.19,40.3 65.19,39.03 65.89,38.33 v1(65.89,38.26)
PM_VDDAADCN: length 2.5
  BOTTOM w0.121: J27.2 46.01,75.35 R501.3
  BOTTOM w0.127: R501.3 46.87,75.35 47.12,75.1
PM_VDDAADCP: length 2.5
  BOTTOM w0.121: J27.1 46.01,76.11 R501.4
  BOTTOM w0.127: 47.15,76.39 46.87,76.11 R501.4
PM_VDDCOREN: length 5.9
  TOP w0.121: v1(64.68,47.79) 64.68,47.54 66.44,45.78 R32.4
  BOTTOM w0.121: U27.9 66.23,47.53 65.97,47.78 65.74,47.78 65.73,47.79 v1(64.68,47.79)
PM_VDDCOREP: length 3.5
  TOP w0.121: v1(65.44,48.42) 67.43,48.42 R32.3
  BOTTOM w0.121: U27.10 65.84,48.03 v1(65.44,48.42)
PM_VDDMPUN: length 5.1
  TOP w0.121: U32.9 68.56,35.65 70.12,34.1 R46.4
PM_VDDMPUP: length 4.7
  TOP w0.121: U32.10 68.56,36.15 69.25,36.85 R46.3
PM_VDDSDDRN: length 2.6
  TOP w0.121: R508.4 113.63,67.48 J20.2
  TOP w0.127: R508.4 113.63,68.4 113.91,68.68
PM_VDDSDDRP: length 2.5
  TOP w0.121: R508.3 112.88,67.48 J20.1
  TOP w0.127: R508.3 112.88,68.4 112.63,68.65
PM_VDDSHV1N: length 2.7
  BOTTOM w0.121: R493.3 121.19,67.6 J26.2
  BOTTOM w0.127: 121.45,68.71 121.19,68.46 R493.3
PM_VDDSHV1P: length 2.6
  BOTTOM w0.121: J26.1 119.67,67.47 120.43,68.24 120.43,68.32 R493.4
  BOTTOM w0.127: 120.16,68.74 120.44,68.46 R493.4
PM_VDDSHV2N: length 2.5
  BOTTOM w0.121: R545.3 113.32,92.88 J38.2
  BOTTOM w0.127: R545.3 113.32,93.8 113.57,94.05
PM_VDDSHV2P: length 2.6
  BOTTOM w0.121: R545.4 112.56,92.88 J38.1
  BOTTOM w0.127: R545.4 112.56,93.8 112.28,94.08
PM_VDDSHV3N: length 2.5
  TOP w0.121: J39.2 131.61,139.67 R546.3
  TOP w0.127: 132.79,139.92 132.53,139.67 R546.3
PM_VDDSHV3P: length 2.6
  TOP w0.121: R546.4 131.61,138.92 J39.1
  TOP w0.127: R546.4 132.53,138.92 132.81,138.64
PM_VDDSHV4N: length 3.3
  BOTTOM w0.121: R494.3 137.7,132.24 J30.2
  BOTTOM w0.127: 135.58,132.49 135.83,132.24 R494.3
PM_VDDSHV4P: length 3.5
  BOTTOM w0.121: R494.4 137.45,131.49 J30.1
  BOTTOM w0.127: R494.4 135.83,131.49 135.55,131.21
PM_VDDSHV5N: length 3.4
  BOTTOM w0.121: R495.3 101.39,144.05 J32.2
  BOTTOM w0.127: 101.13,142.05 101.39,142.31 R495.3
PM_VDDSHV5P: length 3.4
  BOTTOM w0.121: R495.4 102.14,144.05 J32.1
  BOTTOM w0.127: R495.4 102.14,142.31 102.42,142.03
PM_VDDSHV6N: length 2.3
  BOTTOM w0.121: J34.2 51.29,88.62 R496.3
  BOTTOM w0.127: R496.3 51.29,87.95 51.03,87.7
PM_VDDSHV6P: length 2.3
  BOTTOM w0.121: R496.4 52.04,88.62 J34.1
  BOTTOM w0.127: R496.4 52.04,87.95 52.32,87.67
PM_VDDSN: length 2.9
  BOTTOM w0.121: R498.3 101.51,117.76 100.62,118.66
  BOTTOM w0.127: R498.3 101.51,116.53 101.26,116.27
PM_VDDSOSCN: length 2.9
  BOTTOM w0.121: R506.3 113.83,61.64 J29.2
  BOTTOM w0.127: 114.08,63 113.83,62.74 R506.3
PM_VDDSOSCP: length 2.8
  BOTTOM w0.121: J29.1 113.07,61.38 R506.4
  BOTTOM w0.127: R506.4 113.07,62.74 112.79,63.02
PM_VDDSP: length 2.9
  BOTTOM w0.121: J21.1 102.27,117.76 R498.4
  BOTTOM w0.127: R498.4 102.27,116.53 102.55,116.25
PM_VDDSRTCN: length 2.6
  BOTTOM w0.121: R505.3 61.69,47.28 J35.2
  BOTTOM w0.127: R505.3 61.69,48.27 61.95,48.52
PM_VDDSRTCP: length 2.6
  BOTTOM w0.121: R505.4 60.94,47.28 J35.1
  BOTTOM w0.127: R505.4 60.94,48.27 60.66,48.55
PM_VPLLCRLCDN: length 2.9
  BOTTOM w0.121: J24.2 106.59,61.51 R503.3
  BOTTOM w0.127: 106.84,63 106.59,62.74 R503.3
PM_VPLLCRLCDP: length 2.9
  BOTTOM w0.121: R503.4 105.83,61.51 J24.1
  BOTTOM w0.127: R503.4 105.83,62.74 105.55,63.02
PM_VPLLDDRN: length 2.6
  BOTTOM w0.121: R507.4 60.87,53 J33.2
  BOTTOM w0.127: 60.59,54.26 60.87,53.98 R507.4
PM_VPLLDDRP: length 2.6
  BOTTOM w0.121: R507.3 61.63,53 J33.1
  BOTTOM w0.127: R507.3 61.63,53.98 61.88,54.24
PM_VPLLMPUN: length 2.7
  TOP w0.121: J22.2 95.29,117.64 R497.4
  TOP w0.127: R497.4 95.29,116.78 95.01,116.5
PM_VPLLMPUP: length 2.7
  TOP w0.121: J22.1 95.92,117.77 95.92,117.04 R497.3
  TOP w0.127: 96.3,116.53 96.05,116.78 R497.3
PM_VSRAMCOREN: length 2.4
  BOTTOM w0.121: J23.2 46.52,102.27 R500.4
  BOTTOM w0.127: 47.91,102.55 47.63,102.27 R500.4
PM_VSRAMCOREP: length 2.6
  BOTTOM w0.121: J23.1 47.03,101.51 R500.3
  BOTTOM w0.127: 47.89,101.26 47.63,101.51 R500.3
PM_VSRAMMPUN: length 2.4
  BOTTOM w0.121: R499.4 46.9,96.55 J25.2
  BOTTOM w0.127: 47.91,96.83 47.63,96.55 R499.4
PM_VSRAMMPUP: length 2.3
  BOTTOM w0.121: J25.1 46.9,95.8 R499.3
  BOTTOM w0.127: 47.89,95.54 47.63,95.8 R499.3
PM_VUSB1_8VN: length 3.4
  TOP w0.121: R502.4 115.61,143.92 J28.2
  TOP w0.127: R502.4 115.61,142.18 115.33,141.9
PM_VUSB1_8VP: length 3.4
  TOP w0.121: J28.1 116.37,143.92 R502.3
  TOP w0.127: 116.62,141.93 116.37,142.18 R502.3
PM_VUSB3_3VN: length 3.4
  TOP w0.121: J31.2 108.5,143.92 R504.4
  TOP w0.127: R504.4 108.5,142.18 108.22,141.9
PM_VUSB3_3VP: length 3.4
  TOP w0.121: J31.1 109.25,143.92 R504.3
  TOP w0.127: R504.3 109.25,142.18 109.51,141.93
PMIC_DELAYEDRTCPORZ: length 5.9
  TOP w0.121: U1.2 54.29,100.57 53.83,100.11 53.83,99.4 54.14,99.1 55.87,99.1 56.22,98.74 R3.1
PMIC_GPIO: length 126.3
  TOP w0.121: v1(78.02,29.5) 78.02,27.98 79.51,26.48 80.98,26.48 81.46,26.96 85.89,26.96 86.4,26.45 86.4,25.7 86.79,25.31 92.06,25.31 92.95,24.42 94.27,24.42 94.53,24.17 R69.1 C114.1 ; v1(60.87,98.57) 59.83,98.57 59.8,98.54 58.51,98.54 58.3,98.74 R3.2 ; v1(56.5,39.79) 56.62,39.67 78.51,39.67 80.67,37.51 v1(82.21,37.51)
  BOTTOM w0.121: v1(82.21,37.51) 82.59,37.13 82.59,35.47 81.06,33.95 81.06,31.41 80.56,30.9 78.78,30.9 78.02,30.14 v1(78.02,29.5) ; v1(56.5,39.79) 57.39,40.67 57.39,57.01 58.46,58.08 58.46,69.06 61.42,72.03 62.37,72.98 62.37,80.86 61.99,81.25 61.99,81.29 61.96,81.32 61.96,82.74 61.32,83.38 61.32,86.29 60.89,86.72 60.6,87.01 60.6,87.42 60.6,88.01 59.46,89.15 59.46,89.15 59.46,92.07 59.55,92.16 59.55,93.66 59.55,94.32 60.6,95.38 60.6,98.07 60.87,98.34 v1(60.87,98.57)

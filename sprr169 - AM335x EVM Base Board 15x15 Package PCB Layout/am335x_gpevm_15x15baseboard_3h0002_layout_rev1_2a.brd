# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_2a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A8: length 60
  TOP w0.076: U8.K8 v1(69.34,57.44) ; U31.K8 v1(91.56,57.44)
  TOP w0.121: v1(83.86,56.3) 83.22,56.93 83.22,58.23 82.84,58.61 82.84,60.24 83.12,60.51 83.12,63.09 83.37,63.35 83.37,65.81 81.92,67.26 81.92,67.45 80.71,68.66 80.5,68.66 80.21,68.95 79.23,69.93 79.23,70.2 79.17,70.26 v1(79.03,70.26)
  BOTTOM w0.076: 77.91,56.72 77.57,57.06 76.3,57.06 74.97,58.39 70.29,58.39 v1(69.34,57.44) ; 90.91,57.06 91.15,57.31 91.15,57.31 91.28,57.44 v1(91.56,57.44)
  BOTTOM w0.121: v1(79.03,70.26) 78.98,70.31 75.18,70.31 74.21,71.28 74.21,73.7 74.08,73.82 74.08,75.67 R38.2 ; 90.91,57.06 90.84,57 90.84,55.09 90.97,54.96 92.37,54.96 92.49,54.84 92.49,54.01 92.37,53.89 87.08,53.89 86.96,54.01 86.96,55.04 86.54,55.45 85.94,55.45 85.48,55.91 85.36,55.91 85.35,55.92 84.24,55.92 v1(83.86,56.3) 78.33,56.3 77.91,56.72
DDR_A9: length 67
  TOP w0.076: v1(69.34,61.44) U8.K3 ; v1(91.56,62.24) 91.54,62.22 91.54,61.63 91.41,61.51 90.02,61.51 89.89,61.38 89.89,60.68 90.02,60.55 90.28,60.55 90.35,60.63 90.35,61.11 90.43,61.19 90.58,61.19 90.66,61.11 90.66,60.63 90.74,60.55 90.89,60.55 90.96,60.63 90.96,61.11 91.04,61.19 91.19,61.19 91.27,61.11 91.27,60.63 91.34,60.55 91.5,60.55 91.57,60.63 91.57,61.11 91.65,61.19 91.8,61.19 91.88,61.11 91.88,60.63 91.95,60.55 92.49,60.55 92.62,60.68 92.62,61.19 92.52,61.29 92.09,61.29 91.96,61.42 U31.K3
  TOP w0.121: v1(66.27,63.09) 66.01,63.09 65.89,63.22 65.89,64.87 65.76,65 65.06,65 64.93,65.12 64.93,66.65 65.32,67.03 67.54,67.03 67.66,66.9 67.66,66.08 67.79,65.95 69.95,65.95 v1(70.4,65.51) ; v1(81.99,65.15) 81.99,65.68 80.92,66.75 80.92,67.04 80.29,67.66 79.92,67.66 77.57,70.01 77.37,70.01 75.47,70.01 74.52,70.96 R39.2
  BOTTOM w0.076: v1(91.56,62.24) 91.67,62.13 91.67,61.78 91.54,61.66 90.33,61.66 89.85,62.14 89.85,62.72 89.45,63.12 89.45,63.32 89.57,63.44 89.73,63.44 89.85,63.57 89.85,63.85 89.74,63.97 89.33,63.97 ; 67.01,62.35 67.54,61.82 68.93,61.82 69.32,61.44 v1(69.34,61.44)
  BOTTOM w0.121: v1(66.27,63.09) 67.01,62.35 ; v1(70.4,65.51) 70.82,65.93 72.07,65.93 72.08,65.94 72.65,65.94 72.66,65.93 79.02,65.93 79.7,65.25 80.2,65.25 80.45,65 81.85,65 v1(81.99,65.15) 82.04,65.19 82.47,65.19 82.59,65.07 82.59,64.58 82.71,64.46 82.95,64.46 83.07,64.58 83.07,65.07 83.19,65.19 83.43,65.19 83.55,65.07 83.55,64.58 83.67,64.46 83.91,64.46 84.03,64.58 84.03,65.07 84.15,65.19 84.4,65.19 84.52,65.07 84.52,64.58 84.64,64.46 84.88,64.46 85,64.58 85,65.06 85.13,65.19 85.64,65.19 85.76,65.06 85.76,64.87 85.95,64.68 86.81,64.68 87.03,64.46 87.89,64.46 87.9,64.45 88.21,64.45 89.13,64.45 89.24,64.34 89.24,64.2 89.25,64.19 89.25,64.05 89.33,63.97
DDR_A10: length 68.2
  TOP w0.076: U8.H2 71.34,64.62 71.02,64.93 68.43,64.93 68.3,64.81 68.3,64.36 68.43,64.24 70.52,64.24 70.85,63.91 70.85,62.32 v1(70.94,62.24) ; U31.H2 93.56,62.27 93.43,62.14 93.26,62.14 93.13,62.27 93.13,63.47 93.26,63.6 93.43,63.6 93.56,63.73 93.56,64.25 93.69,64.38 93.89,64.38 94.02,64.5 94.02,64.68 93.89,64.81 93.6,64.81 93.51,64.9 93.51,65.03 93.6,65.12 94.84,65.12 94.97,65 94.97,64.43 94.84,64.3 94.46,64.3 94.33,64.17 94.33,63.98 94.46,63.85 94.84,63.85 94.97,63.73 94.97,63.36 94.64,63.03 94.08,63.03 93.95,62.9 93.95,62.24 v1(93.96,62.24)
  LY3 w0.133: v1(86.16,63.41) 86.16,63.93 85.95,64.14 85.95,66.71 81.19,71.47 81.19,73.25 v1(80.62,73.82)
  BOTTOM w0.076: 77.91,63.89 77.49,63.47 71.06,63.47 70.94,63.34 v1(70.94,62.24) ; v1(93.96,62.24) 93.96,63.09 93.83,63.22 93.57,63.22 93.45,63.09 93.45,61.61 93.24,61.4 93.24,61.1 93.45,60.9 93.45,60.55 93.34,60.45 93,60.45 92.87,60.58 92.87,60.84 92.75,60.97 91.22,60.97 91.1,60.84 91.1,60.58 90.97,60.45 90.72,60.45 90.59,60.58 90.59,60.84 90.46,60.97 90.27,60.97 90.14,60.84 90.14,60.58 90.02,60.45 89.83,60.45 89.68,60.6 89.68,61.25 89.55,61.38 89.32,61.38 89.24,61.3
  BOTTOM w0.121: 77.91,63.89 77.94,63.92 78.94,63.92 79.25,63.61 79.34,63.61 79.35,63.6 79.46,63.6 79.89,63.17 79.9,63.17 79.91,63.16 82.55,63.16 82.84,63.46 85.83,63.46 85.88,63.41 v1(86.16,63.41) 86.16,62.9 86.28,62.78 86.78,62.78 86.91,62.9 86.91,63.34 87.03,63.46 87.83,63.46 88.81,62.49 88.81,61.59 89.11,61.3 89.24,61.3 ; R40.2 79.79,73 v1(80.62,73.82)
DDR_A11: length 69.1
  TOP w0.076: U31.K7 v1(91.56,59.04) 91.56,59.09 91.69,59.22 91.99,59.22 92.11,59.35 92.11,59.66 91.99,59.79 89.57,59.79 89.47,59.69 89.47,59.45 89.57,59.35 90.97,59.35 91.1,59.22 91.1,59.02 90.84,58.77 90.84,58.58 90.72,58.46 ; v1(69.34,59.04) U8.K7
  TOP w0.121: R41.2 81.19,71.79 86,66.98 86,64.44 86.6,63.84 86.6,63.23 85.39,62.02 85.39,59.8 v1(84.94,59.35) ; 90.72,58.46 90.27,58.46 90.14,58.33 90.14,57.98 90.02,57.86 89.11,57.86 88.99,57.74 88.99,57.5 89.11,57.38 90.02,57.38 90.14,57.26 90.14,57.02 90.02,56.9 89.11,56.9 88.99,56.78 88.99,56.54 89.11,56.41 90.02,56.41 90.14,56.29 90.14,55.6 90.02,55.47 89.59,55.47 89.47,55.59 89.47,55.92 89.34,56.04 89.1,56.04 88.98,55.92 88.98,55.59 88.86,55.47 87.98,55.47 87.86,55.6 87.86,56.08 87.98,56.2 88.44,56.2 88.56,56.32 88.56,56.56 88.44,56.68 87.98,56.68 87.86,56.8 87.86,57.92 87.98,58.05 v1(88.56,58.05)
  BOTTOM w0.076: 77.91,59.32 77.7,59.54 74.9,59.54 74.65,59.79 74.65,60.18 73.99,60.85 73.99,60.88 73.88,60.98 73.85,60.98 73.84,61 69.89,61 69.76,60.87 69.76,60.62 69.63,60.49 69.38,60.49 69.25,60.62 69.25,60.87 69.13,61 68.87,61 68.74,60.87 68.74,60.62 68.62,60.49 68.43,60.49 68.3,60.62 68.3,60.87 68.17,61 67.98,61 67.86,60.87 67.86,60.22 67.98,60.09 69.82,60.09 69.95,59.96 69.95,59.66 69.82,59.54 68.17,59.54 68.05,59.41 68.05,59.16 68.17,59.03 69.33,59.03 v1(69.34,59.04)
  BOTTOM w0.121: v1(88.56,58.05) 88.56,58.52 88.37,58.71 86.08,58.71 85.51,59.28 85,59.28 v1(84.94,59.35) 84.87,59.28 77.95,59.28 77.91,59.32
DDR_A12: length 69.1
  TOP w0.076: v1(90.76,63.03) 90.33,63.46 90.33,63.79 90.21,63.92 89.45,63.92 89.32,63.79 89.32,63.47 89.45,63.35 90.08,63.35 90.21,63.22 90.21,63.03 90.08,62.9 89.45,62.9 89.32,62.78 89.32,62.52 89.45,62.39 90.4,62.39 90.61,62.6 91.13,62.6 U31.L2 ; 67.01,62.24 v1(68.54,62.24) U8.L2
  TOP w0.121: 67.01,62.24 64.71,62.24 64.42,62.53 64.42,66.96 65.12,67.66 68.43,67.66 68.55,67.54 v1(68.55,67.22) ; v1(81,70.01) 83.38,67.63 83.38,67.51 v1(83.86,67.03)
  BOTTOM w0.076: v1(90.76,63.03) 90.76,63.3 90.46,63.6 90.46,63.62 90.39,63.68 90.39,63.99 90.46,64.05 90.46,64.42 90.38,64.49 90.38,65.01 90.51,65.14 95.73,65.14
  BOTTOM w0.121: v1(81,70.01) 80.33,70.01 79.13,71.22 78.43,71.22 78.02,70.81 76.65,70.81 R42.2 ; 95.73,65.14 95.86,65.26 95.86,65.51 95.73,65.63 92.37,65.63 92.37,65.64 90.42,65.64 90.3,65.76 89.37,65.76 89.25,65.64 88.87,65.64 88.68,65.45 88.31,65.45 88.3,65.45 87.98,65.45 87.86,65.58 87.86,66.65 87.73,66.78 86.33,66.78 86.26,66.85 86.08,67.03 v1(83.86,67.03) 81.12,67.03 80.3,66.21 79.8,66.21 79.33,66.67 72.97,66.67 72.96,66.68 71.28,66.68 71.16,66.81 71.16,67.09 71.03,67.22 v1(68.55,67.22)
DDR_A13: length 68.3
  TOP w0.076: v1(68.54,57.44) U8.L8 ; U31.L8 90.89,57.84 90.76,57.71 90.76,56.36
  TOP w0.121: 90.76,56.36 90.76,56.23 90.89,56.11 93.45,56.11 93.57,55.98 93.57,54.83 93.45,54.7 91.41,54.7 91.29,54.58 91.29,53.82 91.16,53.69 89.91,53.69 89.79,53.82 89.79,54.72 89.67,54.84 89.43,54.84 89.31,54.72 89.31,53.82 89.19,53.69 88.94,53.69 88.82,53.82 88.82,54.72 88.7,54.84 88.46,54.84 88.34,54.72 88.34,53.82 88.22,53.69 87.98,53.69 87.86,53.82 87.86,54.72 87.74,54.84 87.5,54.84 87.38,54.72 87.38,53.82 87.25,53.69 86.59,53.69 86.46,53.82 86.46,56.2 86.59,56.32 v1(86.84,56.32)
  LY3 w0.133: v1(81.51,73.89) 81.51,73.65 81.88,73.28 81.88,72.05 81.7,71.87 81.7,71.47 86.33,66.84 86.33,64.81 86.95,64.19 87.09,64.05 87.09,63.02 85.88,61.81 85.88,56.99 v1(85.44,56.55)
  BOTTOM w0.076: v1(68.54,57.44) 67.28,57.44 67.16,57.56 67.16,58.42 67.31,58.57 76,58.57 77.26,57.31 77.72,57.31 77.91,57.12
  BOTTOM w0.121: R43.2 81.19,74.21 81.51,73.89 v1(81.51,73.89) ; 77.91,57.12 78.48,56.55 83.29,56.55 83.48,56.74 83.91,56.74 83.91,56.74 84.04,56.74 84.61,56.16 85.06,56.16 v1(85.44,56.55) 86.61,56.55 v1(86.84,56.32)
DDR_A14: length 77.6
  TOP w0.076: 89.24,60.55 89.32,60.55 89.45,60.68 89.45,62.17 89.51,62.24 v1(90.76,62.24) ; U8.L3 v1(68.54,61.44) 67.01,61.44 ; U31.L3 89.83,61.84 89.7,61.71 89.7,60.49 89.83,60.36 92.95,60.36 93.06,60.25 93.06,60.11 92.94,59.98 92.94,59.79 93.13,59.6 93.13,59.54 93,59.41 92.49,59.41 92.37,59.54 92.37,59.85 92.24,59.98 89.45,59.98 89.32,59.85 89.32,59.22 89.45,59.09 90.54,59.09 90.65,58.98 90.65,58.82 90.54,58.71 89.95,58.71 89.83,58.58 89.83,58.2 89.73,58.11
  TOP w0.121: 67.01,61.44 65.13,61.44 64.17,62.4 64.17,67.06 65.02,67.91 65.05,67.91 65.12,67.98 68.66,67.98 v1(70.01,66.63) ; 89.24,60.55 89.13,60.55 89,60.43 89,60.24 88.87,60.11 88.62,60.11 88.49,59.98 88.49,59.66 88.62,59.54 88.87,59.54 89,59.41 89,59.16 88.87,59.03 88.55,59.03 88.37,58.85 88.37,58.71 88.49,58.58 88.87,58.58 89,58.46 89,58.2 89.09,58.11 89.73,58.11
  LY3 w0.133: v1(86.94,65.63) 86.94,67.64 83.79,70.78 83.79,71.96 83.01,72.74 82.97,72.74 82.4,73.32 v1(82.4,73.82)
  BOTTOM w0.076: 90.18,65.16 90.18,62.36 90.31,62.24 v1(90.76,62.24)
  BOTTOM w0.121: v1(82.4,73.82) 82.4,74.4 R44.2 ; v1(70.01,66.63) 70.51,66.63 70.7,66.44 72.85,66.44 72.86,66.43 79.23,66.43 79.69,65.96 80.43,65.96 80.79,66.33 85.06,66.33 85.25,66.13 85.8,66.13 86.3,65.63 v1(86.94,65.63) 86.94,66.39 87.07,66.52 87.41,66.52 87.54,66.39 87.54,65.38 87.71,65.21 88.2,65.21 88.21,65.2 88.78,65.2 88.97,65.39 89.35,65.39 89.47,65.51 90.08,65.51 90.18,65.41 90.18,65.16
DDR_BA0: length 61.6
  TOP w0.076: U8.G2 72.49,62.64 72.68,62.83 72.68,63.09 72.65,63.12 71.86,63.12 71.74,62.99 v1(71.74,62.24) ; v1(94.76,62.24) U31.G2
  TOP w0.121: v1(72.39,70.57) 71.92,70.1 71.92,68.43 72.05,68.3 73.32,68.3 73.44,68.43 73.44,68.87 73.57,68.99 77.19,68.99 77.57,68.61 77.57,67.16 79.29,65.44 79.29,64.05 80.05,63.28 v1(80.05,62.46)
  BOTTOM w0.076: 77.91,62.37 77.34,62.37 77.25,62.46 77.25,62.59 77.34,62.68 77.91,62.68 ; v1(94.76,62.24) 93.98,61.45 93.98,60.93 94.11,60.81 94.46,60.81 94.59,60.68 94.59,60.24 94.46,60.11 89.47,60.11 89.24,60.34 ; v1(71.74,62.24) 71.6,62.24 71.5,62.34 71.5,62.99 71.6,63.09 77.85,63.09 77.91,63.04
  BOTTOM w0.121: 77.91,63.04 79.31,63.04 79.41,62.93 79.41,62.78 79.31,62.68 77.91,62.68 ; R47.2 72.49,78.71 72.49,78.16 72.56,78.09 72.56,74.21 72.07,73.73 72.07,70.87 72.36,70.59 72.37,70.59 v1(72.39,70.57) ; 77.91,62.37 79.96,62.37 v1(80.05,62.46) 80.15,62.57 82.89,62.57 83.29,62.96 84.37,62.96 85.06,62.27 85.83,62.27 86.36,61.73 87.97,61.73 88.91,60.79 88.91,60.66 89.24,60.34
DDR_BA1: length 74.8
  TOP w0.076: v1(71.74,61.44) 71.73,61.43 71.73,60.43 71.6,60.3 67.01,60.3 ; v1(94.35,61.25) 94.35,60.68 94.47,60.55 98.4,60.55 98.53,60.43 98.53,59.71 98.64,59.6 98.79,59.6 98.91,59.71 98.91,60.62 99.03,60.74 99.21,60.74 99.34,60.62 99.34,59.73 99.46,59.6 99.86,59.6 99.99,59.73 99.99,59.92 99.8,60.11 99.8,60.68 99.29,61.19 99.03,61.19 98.91,61.07 98.61,61.07 98.49,61.19 98.23,61.19 98.11,61.07 97.81,61.07 97.69,61.19 97.43,61.19 97.31,61.07 97.01,61.07 96.89,61.19 96.63,61.19 96.51,61.07 96.21,61.07 96.09,61.19 95.83,61.19 95.71,61.07 94.97,61.07 94.84,61.19 94.84,61.71 94.72,61.84 U31.G3 ; U8.G3 72.14,59.88 71.92,59.66 67.01,59.66
  TOP w0.121: 67.01,59.66 64.74,59.66 64.62,59.79 64.62,60.17 64.74,60.3 67.01,60.3 ; R49.2 79.79,70.65 79.79,70.06 80.7,69.16 80.71,69.16 80.91,69.16 82.12,67.94 82.41,67.65 82.41,67.47 83.87,66.01 83.87,62.57 v1(83.92,62.52)
  BOTTOM w0.076: 77.91,62.08 77.86,62.13 77.2,62.13 77.06,62.27 77.06,62.65 76.81,62.9 72.55,62.9 72.11,62.46 72.11,61.84 72.12,61.83 72.12,61.82 v1(71.74,61.44) ; v1(94.35,61.25) 94.65,61.25 94.78,61.12 94.78,60.2 94.52,59.94 89.24,59.94
  BOTTOM w0.121: 89.24,59.94 88.67,60.5 88.67,60.69 87.87,61.49 86.23,61.49 85.7,62.01 84.43,62.01 v1(83.92,62.52) 83.29,62.52 83.08,62.32 80.54,62.32 80.3,62.08 80.29,62.08 80.23,62.02 79.48,62.02 79.37,62.12 78.52,62.12 78.39,62 77.99,62 77.91,62.08
DDR_BA2: length 60.4
  TOP w0.076: 71.63,65.16 71.67,65.12 ; v1(93.96,63.84) U31.G1 ; v1(71.74,63.84) 71.74,64.55 ; 72.14,64.65 U8.G1
  TOP w0.121: 71.63,65.16 71.54,65.25 71.54,66.14 71.41,66.27 71.16,66.27 71.03,66.39 71.03,67.35 70.9,67.47 70.59,67.47 70.46,67.35 70.46,66.07 70.64,65.89 70.78,65.89 70.9,65.76 70.9,65.23 71.02,65.11 71.09,65.11 71.1,65.1 71.18,65.1 71.74,64.55 ; 71.67,65.12 72.14,64.65 ; R549.2 72.43,75.35 72.43,73.85 72.02,73.44 72.02,71.31 71.62,70.9 71.62,68.81 71.49,68.68 70.52,68.68 70.4,68.55 70.4,67.86 70.52,67.73 73.63,67.73 73.76,67.86 73.76,68.62 73.89,68.74 76.36,68.74 76.49,68.62 76.49,67.73 76.62,67.6 76.62,67.6 76.75,67.47 76.75,66.77 78.52,65 v1(78.52,64.68)
  BOTTOM w0.076: 89.27,61.93 90.08,61.12 92.87,61.12 93,61.25 93,62.88 93.41,63.28 93.41,63.71 93.53,63.84 v1(93.96,63.84)
  BOTTOM w0.121: 89.27,61.93 89.27,62.36 89.13,62.5 89.13,62.52 87.94,63.71 87.91,63.71 87.59,63.71 87.58,63.72 86.72,63.72 86.53,63.91 85.89,63.91 85.68,63.71 82.74,63.71 82.45,63.41 80.05,63.41 80.04,63.42 79.99,63.42 79.55,63.86 79.35,63.86 78.91,64.3 78.9,64.3 v1(78.52,64.68) 78.04,65.16 71.6,65.16 71.47,65.03 71.47,63.96 71.6,63.84 v1(71.74,63.84)
DDR_CASN: length 67
  TOP w0.076: U8.G7 v1(71.74,59.04) ; U31.G7 v1(93.96,59.04)
  TOP w0.121: R13.2 80.24,71.67 80.49,71.41 81.06,71.41 85.26,67.21 85.26,62.72 84.87,62.33 84.87,60.16 84.75,60.04 84.5,60.04 84.25,59.79 84.25,59.27 84.25,59.06 84.65,58.66 84.94,58.66 85.06,58.53 85.06,57.89 84.94,57.76 v1(84.44,57.76)
  BOTTOM w0.076: v1(93.96,59.04) 93.96,58.14 93.83,58.01 90.91,58.01 90.69,58.23 90.69,58.61 90.46,58.84 90.21,58.84 90.08,58.71 90.08,57.06 90.33,56.81 ; 77.91,57.95 77.85,57.95 77.73,58.08 77.73,58.4 ; v1(71.74,59.04) 71.47,59.04 71.35,59.16 71.35,59.35 71.22,59.47 70.9,59.47 70.78,59.6 70.78,60.36 70.88,60.46 71.12,60.46 71.22,60.36 71.22,59.85 71.35,59.73 71.86,59.73 71.96,59.83 71.96,60.34 72.08,60.46 73.72,60.46 74.14,60.05 74.14,59.16 74.33,58.97 76.62,58.97 76.75,58.84 76.75,58.75 76.87,58.63
  BOTTOM w0.121: 76.87,58.63 77.5,58.63 77.73,58.4 ; 84.43,57.76 84.43,57.76 85.13,57.76 85.25,57.63 85.25,57.38 85.38,57.25 85.89,57.25 86.02,57.38 86.02,57.82 86.14,57.95 86.32,57.95 86.44,57.82 86.44,57.49 86.57,57.36 87.41,57.36 87.53,57.23 87.53,54.58 87.66,54.46 88.75,54.46 88.87,54.58 88.87,56.49 89,56.62 89.32,56.62 89.45,56.49 89.45,54.58 89.57,54.46 90.21,54.46 90.33,54.58 90.33,56.81 ; 84.43,57.76 84.23,57.95 83.87,57.95 83.75,57.83 83.75,57.69 83.63,57.57 83.39,57.57 83.27,57.69 83.27,57.83 83.15,57.95 82.91,57.95 82.79,57.83 82.79,57.69 82.67,57.57 82.42,57.57 82.3,57.69 82.3,57.83 82.18,57.95 81.94,57.95 81.82,57.83 81.82,57.69 81.7,57.57 80.91,57.57 80.78,57.69 80.78,58.41 80.66,58.53 80.42,58.53 80.3,58.41 80.3,57.82 80.17,57.7 79.94,57.7 79.82,57.82 79.82,58.41 79.69,58.53 79.45,58.53 79.33,58.41 79.33,58.01 79.21,57.89 78.98,57.89 78.85,58.01 78.85,58.41 78.73,58.53 78.49,58.53 78.37,58.41 78.37,58.07 78.25,57.95 77.91,57.95 ; 84.43,57.76 v1(84.44,57.76)
DDR_CKE: length 72.4
  TOP w0.076: U8.F2 72.94,64.24 72.81,64.36 72.74,64.36 71.95,65.16 ; v1(95.56,62.24) 95.6,62.28 95.6,63.07 95.34,63.33 95.16,63.33 94.84,63.02 94.84,62.76 94.97,62.64 U31.F2 ; v1(72.54,62.24) 73.28,62.24 73.38,62.33 73.38,62.84 73.63,63.09 73.93,63.09 74.05,63.22 74.05,64.45 73.89,64.62 72.87,64.62 72.64,64.85 72.64,65.16
  TOP w0.121: 71.95,65.16 71.95,65.32 71.79,65.47 71.79,66.27 71.35,66.71 71.35,67.28 71.54,67.47 72.51,67.47 72.64,67.35 72.64,65.16
  LY3 w0.133: v1(78.84,73.89) 79.73,73 79.73,71.73 80.17,71.28 80.43,71.28 84.8,66.91 84.8,66.65 85.01,66.45 85.01,65.58 84.61,65.18 84.61,62.24 84.43,62.05 v1(84.43,61.44)
  BOTTOM w0.076: 77.91,61.75 77.86,61.75 77.63,61.97 77.01,61.97 76.9,62.08 76.9,62.59 76.75,62.75 72.64,62.75 72.54,62.65 v1(72.54,62.24) ; 89.51,59.66 89.58,59.73 94.53,59.73 94.97,60.17 94.97,61.92 95.13,62.08 95.13,62.39 94.97,62.55 94.97,63.34 95.1,63.47 98.11,63.47 98.33,63.68 98.33,63.92 98.46,64.05 99.06,64.05 99.17,63.94 99.17,63.52 99.22,63.47 99.48,63.47 99.61,63.34 99.61,63.12 99.48,62.99 98.59,62.99 98.37,62.78 95.69,62.78 95.56,62.65 v1(95.56,62.24)
  BOTTOM w0.121: 89.51,59.66 89.16,59.66 88.42,60.4 88.42,60.58 87.77,61.24 86.09,61.24 85.89,61.44 85.52,61.44 85.32,61.24 84.63,61.24 v1(84.43,61.44) 82.65,61.44 82.52,61.57 82.52,61.94 82.4,62.07 80.7,62.07 80.38,61.75 79.32,61.75 79.19,61.88 78.62,61.88 78.49,61.75 77.91,61.75 ; R537.2 79.29,74.33 v1(78.84,73.89)
DDR_CLK: length 62.8
  TOP w0.095: U31.E8 95.59,58.2 v1(94.77,58.2) ; R11.2 77.38,71.3 80.26,68.43 80.61,68.43 81.68,67.35 81.68,67.07 82.41,66.33 82.51,66.33 82.95,65.9 82.95,63.55 82.85,63.45 82.61,63.21 82.61,60.34 82.61,57.05 82.8,56.86 82.8,56.46 83.5,55.77 83.87,55.77 84.1,55.77 84.39,55.48 84.39,54.96 84.53,54.81 v1(84.53,54.36) ; v1(73.34,57.44) U8.E8
  BOTTOM w0.095: v1(73.34,57.44) 73.46,57.31 73.71,57.31 74.52,56.5 74.52,54.21 74.23,53.92 72.61,53.92 72.3,53.62 72.3,52.88 72.5,52.68 80.94,52.68 82.8,54.55 83.3,54.55 83.4,54.57 83.73,54.57 v1(84.53,54.36) 84.54,54.36 84.82,54.36 84.98,54.21 85.15,54.21 85.44,53.92 85.44,51.5 85.57,51.37 94.07,51.37 94.45,51.75 94.45,56.02 94.48,56.05 94.48,57.18 94.38,57.28 94.38,57.81 94.77,58.19 v1(94.77,58.2)
DDR_CLKN: length 63.6
  TOP w0.095: v1(94.76,57.44) U31.F8 ; R12.2 76.43,71.32 76.55,71.19 77.1,71.19 80.14,68.15 80.49,68.15 81.4,67.24 81.4,66.95 82.3,66.05 82.4,66.05 82.67,65.78 82.67,63.67 82.57,63.57 82.33,63.33 82.33,60.22 82.33,56.94 82.52,56.74 82.52,56.35 83.38,55.49 83.98,55.49 84.07,55.41 84.07,55.4 84.11,55.36 84.11,54.24 84.01,54.14 v1(83.58,54.14) ; v1(72.54,57.44) U8.F8
  BOTTOM w0.095: v1(72.54,57.44) 73.19,57.01 73.49,57.01 73.63,56.87 73.76,56.87 74.24,56.39 74.24,54.33 74.12,54.2 72.49,54.2 72.02,53.73 72.02,52.77 72.39,52.4 81.05,52.4 82.84,54.19 83.1,54.19 83.15,54.14 v1(83.58,54.14) 84.05,54.14 84.25,53.93 85.04,53.93 85.17,53.81 85.17,51.38 85.46,51.09 94.18,51.09 94.73,51.64 94.73,55.9 94.76,55.93 v1(94.76,57.44)
DDR_CSN: length 66.6
  TOP w0.076: U31.G8 v1(93.96,57.44) 93.96,56.36 ; v1(71.74,57.44) U8.G8
  TOP w0.121: 93.96,56.36 93.96,55.41 94.09,55.29 95.34,55.29 95.47,55.41 96.94,55.41 97.07,55.28 97.07,54.59 96.94,54.46 93.77,54.46 93.64,54.33 93.64,53.5 93.51,53.38 93.32,53.38 93.19,53.5 93.19,54.33 93.06,54.46 92.81,54.46 92.68,54.33 92.68,53.5 92.56,53.38 92.24,53.38 92.11,53.5 92.11,54.33 91.99,54.46 91.73,54.46 91.6,54.33 91.6,53.5 91.48,53.38 85.76,53.38 85.64,53.5 85.64,54.33 85.76,54.46 v1(86.02,54.46) 86.02,54.87 86.15,55.01 86.15,56.5 86.72,57.07 86.72,60.31 88.38,61.96 88.38,65.3 87.88,65.8 87.88,66.02 87.68,66.21 87.68,66.97 84.62,70.03 84.62,71.16 84.05,71.73 R538.2
  BOTTOM w0.076: 74.82,56.36 74.82,56.57 73.52,57.88 71.86,57.88 71.74,57.76 v1(71.74,57.44)
  BOTTOM w0.121: v1(86.02,54.46) 85.06,54.46 84.62,54.9 81.63,54.9 81.51,54.77 81.51,53.58 80.86,52.93 74.33,52.93 74.21,53.06 74.21,53.44 74.33,53.57 74.76,53.57 74.89,53.69 74.89,56.19 74.82,56.26 74.82,56.36
DDR_D0: length 41.6
  TOP w0.076: U8.C8 75.03,57.84 74.9,57.96 74.9,60.11 75.01,60.21 75.37,60.21 75.48,60.11 75.48,59.03 75.6,58.9 75.79,58.9 75.92,59.03 75.92,60.04 76.05,60.17 76.3,60.17 76.43,60.04 76.43,59.43 76.55,59.31 76.75,59.31 76.87,59.43 76.87,60.11 76.97,60.21 77.21,60.21 77.32,60.11 77.32,59.52 77.43,59.41 77.91,59.41
  TOP w0.121: 77.91,59.41 77.95,59.41 78.21,59.16 78.21,57.41 78.41,57.21 78.41,56.68 78.53,56.55 78.78,56.55 78.9,56.68 78.9,59.73 78.78,59.85 v1(78.4,59.85)
  LY3 w0.133: v1(87.22,59.16) 87.22,60.62 88.61,62.01 88.61,64.91 89.06,65.37 89.06,66.65 87.79,67.92 87.79,70.52 88.37,71.09 88.37,71.47 88.33,71.51 v1(88.33,71.57)
  BOTTOM w0.121: v1(87.22,59.16) 87.1,59.28 86.33,59.28 86.21,59.41 86.21,59.73 86.08,59.85 v1(78.4,59.85) ; R429.2 87.92,71.98 v1(88.33,71.57)
DDR_D1: length 37.6
  TOP w0.076: U8.C2 75.34,62.97 75.46,63.09 77.13,63.09 77.25,62.97 77.25,62.14
  TOP w0.121: 77.25,62.14 77.38,62.01 77.63,62.01 77.76,62.14 77.76,65.06 77.12,65.7 75.35,65.7 75.22,65.82 v1(75.22,68.05)
  LY3 w0.133: v1(90.02,71.23) 90.01,71.22 89.95,71.22 89.13,70.4 89.13,69.38 v1(88.26,68.51)
  BOTTOM w0.121: v1(75.22,68.05) 75.25,68.08 75.64,68.08 75.77,68.2 75.77,68.78 76.04,69.05 76.04,69.94 76.17,70.06 78.14,70.06 78.27,69.94 78.27,69.54 78.14,69.41 76.68,69.41 76.56,69.28 76.56,68.37 76.82,68.11 77.18,68.11 77.44,68.37 77.44,68.64 77.71,68.92 86.3,68.92 86.7,68.51 v1(88.26,68.51) ; v1(90.02,71.23) 90.02,71.86 89.45,72.43 R522.2
DDR_D2: length 41.6
  TOP w0.076: U8.D7 74.54,59.54 74.41,59.66 72.68,59.66 72.55,59.79 72.55,60.24 72.68,60.36 77.78,60.36
  TOP w0.121: v1(79.73,60.49) 79.73,56.55 79.6,56.43 79.35,56.43 79.22,56.55 79.22,59.98 78.85,60.36 77.79,60.36 77.78,60.36 ; v1(88.11,59.22) 88.11,60.06 89.12,61.07 89.12,64.7 90.72,66.31 90.72,68.37 91.67,69.32 R523.2
  BOTTOM w0.121: v1(88.11,59.22) 87.84,59.22 87.45,59.61 87.45,59.61 87.33,59.72 86.75,59.72 86.62,59.85 86.62,59.98 86.5,60.11 80.11,60.11 79.98,60.24 79.98,60.25 79.74,60.49 v1(79.73,60.49)
DDR_D3: length 39.8
  TOP w0.076: 77.91,60.87 75.03,60.87 74.94,60.97 v1(74.94,61.44) U8.D3
  TOP w0.121: v1(91.41,68.05) 91.86,68.05 92.62,68.81 R524.2 ; 77.91,60.87 78.14,60.87 78.27,61 78.27,61.7 78.4,61.82 79.22,61.82 79.35,61.7 79.35,61.06 79.47,60.93 79.67,60.93 79.79,61.06 79.79,62.09 79.55,62.33 79.09,62.33 78.96,62.46 78.96,62.9 79.09,63.03 79.35,63.03 79.48,63.16 79.48,63.41 79.35,63.54 79.09,63.54 78.96,63.66 78.96,65.41 78.66,65.71 78.16,65.71 77.89,65.98 77.89,66.49 77.73,66.65 77.22,66.65 77,66.87 v1(77,68.55)
  BOTTOM w0.121: v1(91.41,68.05) 92.18,68.05 92.3,68.17 92.3,68.37 91.87,68.8 90.94,68.8 88.62,68.8 88.47,68.95 87.63,68.95 87.46,68.79 86.78,68.79 86.4,69.16 77.61,69.16 v1(77,68.55)
DDR_D4: length 40.6
  TOP w0.076: 75.03,65.06 75.03,63.93 v1(74.94,63.84) U8.D1
  TOP w0.121: 75.03,65.06 74.9,65.19 73.38,65.19 73.25,65.32 73.25,66.27 73.38,66.39 74.27,66.39 74.4,66.52 v1(74.4,67.22)
  LY3 w0.133: v1(90.27,73.95) 90.27,73.5 90.02,73.24 90.02,72.3 90.52,71.8 90.52,71.47 90.52,71.47 90.52,70.84 89.7,70.01 89.7,67.66 v1(89.32,67.28)
  BOTTOM w0.121: v1(89.32,67.28) 89.04,67.28 88.8,67.53 86.63,67.53 85.99,68.17 80.24,68.17 80.22,68.16 80.1,68.16 79.23,67.29 78.09,67.29 77.79,67.59 76,67.59 75.76,67.35 74.94,67.35 74.8,67.5 74.43,67.86 74.02,67.86 73.76,68.12 73.76,68.49 73.93,68.65 73.93,69.63 74.05,69.76 74.33,69.76 74.46,69.89 74.46,70.33 74.33,70.46 73.75,70.46 73.42,70.13 72.93,70.13 72.43,69.63 72.43,68.52 73.27,67.68 73.54,67.68 74,67.22 v1(74.4,67.22) ; v1(90.27,73.95) 90.08,73.76 R525.2
DDR_D5: length 44.2
  TOP w0.076: 74.08,56.36 74.08,59.35 73.95,59.47 72.49,59.47 72.36,59.6 72.36,60.49 72.49,60.62 77.72,60.62 ; U8.D9 74.54,56.36
  TOP w0.121: 74.54,56.36 74.54,54.2 74.41,54.08 74.21,54.08 74.08,54.2 74.08,56.36 ; v1(78.9,61.19) 78.33,60.62 77.72,60.62
  LY3 w0.133: v1(87.73,60.3) 88.87,61.44 88.87,64.81 90.48,66.41 90.48,68.51 91.46,69.49 91.46,73.01 91.16,73.31 v1(91.16,73.89)
  BOTTOM w0.121: v1(91.16,73.89) 91.16,74.65 R526.2 ; v1(78.9,61.19) 79.19,61.19 79.25,61.24 80.87,61.24 81.13,61.5 81.57,61.5 82.4,60.68 87.35,60.68 v1(87.73,60.3)
DDR_D6: length 38.1
  TOP w0.076: U8.B1 v1(76.54,63.84) 76.54,65.16
  TOP w0.121: v1(92.18,71.47) 92.18,69.45 90.97,68.24 90.97,67.28 v1(91.29,66.97) ; v1(74.21,68.3) 74.21,68.3 74.84,67.67 74.84,67.03 74.84,67.02 74.84,66.27 74.71,66.14 73.63,66.14 73.5,66.01 73.5,65.57 73.63,65.44 76.25,65.44 76.54,65.16
  BOTTOM w0.121: R527.2 92.24,71.53 v1(92.18,71.47) ; v1(91.29,66.97) 90.77,66.97 90.2,67.53 89.77,67.53 89.51,67.79 86.72,67.79 86.23,68.28 86.09,68.42 80.01,68.42 79.13,67.54 78.2,67.54 77.89,67.85 76.02,67.85 76.01,67.84 75.89,67.84 75.65,67.6 75.04,67.6 74.78,67.87 74.78,68.9 74.91,69.03 75.67,69.03 75.79,69.15 75.79,69.38 75.67,69.51 74.33,69.51 74.21,69.38 v1(74.21,68.3)
DDR_D7: length 37.6
  TOP w0.121: v1(81.13,65.51) 81.25,65.38 81.25,61.63 80.81,61.19 80.81,54.46 80.68,54.33 76.26,54.33 76.14,54.46 U8.B9 ; v1(89.64,64.36) 89.64,64.87 91.1,66.33 91.97,66.33 93.89,68.25 v1(93.89,70.84)
  BOTTOM w0.076: 89.3,64.7 v1(89.64,64.36)
  BOTTOM w0.121: v1(81.13,65.51) 81.21,65.59 83.35,65.59 83.49,65.44 85.76,65.44 86.26,64.94 86.86,64.94 86.87,64.94 86.9,64.94 87.13,64.71 87.99,64.71 88,64.7 88.32,64.7 89.3,64.7 ; R528.2 93.38,71.35 v1(93.89,70.84)
DDR_D8: length 46.2
  TOP w0.076: v1(97.96,57.44) U31.C8
  TOP w0.121: R529.2 85.7,71.41 85.7,71.27 85.95,71.02 85.95,70.72 86.33,70.33 86.33,69.32 88.18,67.47 88.18,66.8 v1(88.43,66.55)
  BOTTOM w0.076: 100.14,62.84 98.65,62.84 98.39,62.58 98.39,62.08 98.18,61.87 97.07,61.87 96.79,61.59 96.79,61.28 96.94,61.14 96.94,60.49 96.81,60.36 96.11,60.36 95.99,60.24 95.99,59.7 96.11,59.57 96.87,59.57 97,59.45 97,59.18 96.87,59.05 96.05,59.05 95.92,58.93 95.92,58.52 96.05,58.39 96.43,58.39 96.56,58.27 96.56,57.19 96.74,57 97.53,57 v1(97.96,57.44)
  BOTTOM w0.121: 100.14,62.84 100.43,62.84 100.68,62.58 100.68,59.73 100.81,59.6 101.89,59.6 102.02,59.73 102.02,66.2 101.89,66.33 96.44,66.33 96.24,66.13 90.63,66.13 90.42,66.34 88.64,66.34 v1(88.43,66.55)
DDR_D9: length 46.2
  TOP w0.076: 100.14,64.48 100.03,64.48 100.01,64.46 96.49,64.46 96.37,64.33 96.37,63.16 96.49,63.03 97.4,63.03 97.52,62.9 97.52,62.67 U31.C2
  TOP w0.121: 100.14,64.48 100.24,64.48 100.36,64.36 102.74,64.36 102.86,64.49 102.86,65.68 102.74,65.81 101.65,65.81 101.15,66.32 101.15,67.54 101.02,67.66 98.33,67.66 98.2,67.54 98.2,65.91 98.02,65.73 98.02,65.57 97.89,65.45 96.3,65.45 96.18,65.57 96.18,66.2 97,67.03 97,68.43 97.13,68.55 101.13,68.55 101.26,68.68 v1(101.26,69.06) ; v1(86.97,70.45) 86.85,70.45 86.47,70.83 86.47,70.84 86.21,71.1 86.21,71.34 85.95,71.6 R530.2
  BOTTOM w0.121: v1(86.97,70.45) 87.15,70.27 87.54,70.27 87.87,69.94 88.96,69.94 89.11,69.79 91.48,69.79 92.28,69.79 92.91,69.16 93.32,69.16 94.28,69.16 95.55,69.16 95.84,69.45 101.13,69.45 101.26,69.33 v1(101.26,69.06)
DDR_D10: length 42.5
  TOP w0.076: 100.01,59.41 96.89,59.41 96.76,59.28 U31.D7
  TOP w0.121: v1(88.3,70.4) 87.73,70.4 87.16,70.97 87.16,71.41 86.91,71.67 R531.2 ; v1(102.41,68.93) 102.46,68.88 102.46,68.68 102.34,68.55 102.02,68.55 101.89,68.43 101.89,66.68 102.02,66.55 103.48,66.55 103.61,66.43 103.61,62.87 103.48,62.75 103.18,62.75 103.05,62.62 103.05,56.62 102.93,56.49 102.08,56.49 101.95,56.62 101.95,59.28 101.82,59.41 100.01,59.41
  BOTTOM w0.121: v1(88.3,70.4) 88.61,70.4 88.62,70.38 88.88,70.38 89.23,70.04 91.58,70.04 92.38,70.04 93.01,69.41 93.22,69.41 95.44,69.41 95.73,69.7 99.73,69.7 99.92,69.89 101.29,69.89 101.66,69.51 101.83,69.51 101.83,69.51 102.28,69.51 102.41,69.38 v1(102.41,68.93)
DDR_D11: length 43.7
  TOP w0.076: v1(97.16,61.44) U31.D3
  LY3 w0.133: v1(85.81,70.09) 85.54,70.09 84.24,71.39 84.24,73.02 84.05,73.21 v1(84.05,73.95)
  BOTTOM w0.076: v1(97.16,61.44) 97.16,60.33 97.43,60.06 100.06,60.06
  BOTTOM w0.121: v1(85.81,70.09) 85.89,70.01 87.42,70.01 87.73,69.7 88.86,69.7 89.01,69.55 91.38,69.55 92.18,69.55 92.81,68.92 93.43,68.92 94.38,68.92 95.65,68.92 95.94,69.21 100.68,69.21 100.81,69.08 100.81,68.62 100.94,68.49 102.59,68.49 102.72,68.62 103.29,68.62 103.42,68.49 103.42,58.65 103.29,58.52 100.26,58.52 100.14,58.65 100.14,59.98 100.06,60.06 ; R532.2 v1(84.05,73.95)
DDR_D12: length 44.2
  TOP w0.076: 100.14,64.24 97.29,64.24 97.16,64.11 v1(97.16,63.84) U31.D1
  TOP w0.121: v1(88.49,65.89) 88.47,65.89 87.93,66.43 87.93,67.27 85.38,69.82 85.38,69.89 85.37,69.9 85.37,70.27 85.38,70.28 85.38,70.71 v1(85.51,70.84) ; v1(96.62,65.89) 97.83,65.89 97.95,66.01 97.95,67.79 98.08,67.92 101.27,67.92 101.4,67.79 101.4,66.42 101.76,66.06 102.98,66.06 103.11,65.93 103.11,63.37 102.98,63.24 102.97,63.24 102.85,63.11 102.56,62.82 102.56,60.55 102.43,60.43 100.43,60.43 100.3,60.55 100.3,64.07 100.14,64.24 100.14,64.24
  BOTTOM w0.121: v1(85.51,70.84) 85.51,70.84 85.51,74.21 R533.2 ; v1(88.49,65.89) 89.15,65.89 89.35,66.09 90.32,66.09 90.52,65.89 v1(96.62,65.89)
DDR_D13: length 46.5
  TOP w0.076: v1(97.16,56.64) U31.D9
  TOP w0.121: v1(100.75,56.68) 100.75,55.79 100.88,55.66 103.67,55.66 103.8,55.79 103.8,61.82 103.92,61.95 104.24,61.95 104.37,62.08 104.37,67.47 104.24,67.6 v1(102.97,67.6)
  LY3 w0.133: v1(86.65,71.28) 87.04,70.9 87.15,70.9 87.42,70.63 87.42,69.95 87.18,69.72 v1(87.18,69.48)
  BOTTOM w0.076: 98.41,56.36 98.33,56.44 98.33,56.81 98.14,57 97.81,57 97.44,56.64 v1(97.16,56.64) ; 99.11,56.36 99.19,56.44 99.19,56.83 99.36,57 100.13,57 100.14,57
  BOTTOM w0.121: R534.2 86.84,74.65 86.4,74.21 86.4,73.82 86.14,73.57 86.14,71.79 v1(86.65,71.28) ; 99.11,56.36 98.94,56.19 98.58,56.19 98.41,56.36 ; v1(100.75,56.68) 100.43,57 100.14,57 ; v1(102.97,67.6) 102.97,68.12 102.84,68.24 100.84,68.24 100.12,68.96 96.05,68.96 95.76,68.67 94.48,68.67 93.53,68.67 92.71,68.67 92.08,69.3 91.27,69.3 88.91,69.3 88.76,69.45 87.21,69.45 v1(87.18,69.48)
DDR_D14: length 40.3
  TOP w0.076: U31.B1 98.36,63.39 98.72,63.03 99.67,63.03 100.02,62.68 100.02,60.84
  TOP w0.121: v1(101.2,70.66) 101.7,70.66 101.83,70.53 101.83,68.71 101.64,68.53 101.64,66.52 101.86,66.31 103.23,66.31 103.36,66.18 103.36,63.12 103.23,62.99 103.08,62.99 102.95,62.87 102.81,62.72 102.81,60.24 102.68,60.11 100.14,60.11 100.02,60.24 100.02,60.84
  BOTTOM w0.121: v1(101.2,70.66) 101,70.85 99.48,70.85 99.35,70.73 99.35,70.08 99.22,69.95 98.91,69.95 98.78,70.08 98.78,70.73 98.65,70.85 98.14,70.85 98.02,70.73 98.02,70.08 97.89,69.95 97.51,69.95 97.38,70.08 97.38,70.73 97.26,70.85 96.87,70.85 96.75,70.73 96.75,70.08 96.62,69.95 95.35,69.95 95.06,69.66 93.12,69.66 92.68,70.09 92.49,70.29 92.17,70.29 91.69,70.29 91.68,70.29 89.35,70.29 88.79,70.85 87.79,70.85 87.79,70.84 87.42,70.84 87.09,71.17 87.09,72.24 R535.2
DDR_D15: length 40
  TOP w0.076: v1(98.76,56.64) U31.B9
  TOP w0.121: v1(90.97,71.28) 90.65,71.6 90.27,71.6 R536.2
  BOTTOM w0.076: 100.14,57.39 99.38,57.39 99.19,57.21 99.19,57.07 v1(98.76,56.64)
  BOTTOM w0.121: 100.14,57.39 100.24,57.39 100.37,57.52 100.37,58.1 100.49,58.23 101.32,58.23 101.45,58.1 101.45,55.22 101.57,55.09 103.42,55.09 103.66,55.34 103.66,69.83 101.89,71.6 96.43,71.6 95.52,70.69 94.57,70.69 94.28,70.4 93.43,70.4 92.79,71.03 91.22,71.03 v1(90.97,71.28)
DDR_DQM0: length 41
  TOP w0.076: U8.B3 v1(76.54,61.44) 76.54,61.21 76.68,61.06 77.7,61.06 77.91,61.27
  TOP w0.121: 77.91,61.27 78.02,61.38 78.02,62.42 78.14,62.54 78.6,62.54 78.72,62.66 78.72,62.9 78.6,63.02 78.14,63.02 78.02,63.14 78.02,63.38 78.14,63.5 78.6,63.5 78.72,63.62 78.72,63.87 78.6,63.99 78.14,63.99 78.02,64.11 78.02,64.62 78.01,64.62 78.01,65.16 77.23,65.94 75.67,65.94 75.48,66.14 75.48,67.68 75.66,67.87 75.66,68.36 75.79,68.49 76.05,68.49 76.17,68.36 76.17,67.16 v1(76.18,67.15) ; R16.2 91.1,71.73 91.15,71.73 91.41,71.47 91.41,71.41 91.41,71.41 91.41,69.79 90.94,69.32 90.72,69.32 90.59,69.44 90.59,70.27 90.46,70.4 90.05,70.4 89.57,69.92 89.57,69.13 89.7,69 90.14,69 90.27,68.87 90.27,68.68 90.14,68.55 89.7,68.55 89.57,68.43 89.57,68.05 90.02,67.6 v1(90.02,67.04)
  BOTTOM w0.121: v1(76.18,67.15) 76.58,67.15 76.81,66.92 77,66.92 77.13,67.05 77.13,67.22 77.25,67.34 77.44,67.34 77.57,67.22 77.57,67.03 77.68,66.92 79.21,66.92 80.2,67.91 83.69,67.91 85.9,67.91 86.53,67.28 88.69,67.28 89.14,66.84 89.5,66.84 89.5,66.85 89.83,66.85 v1(90.02,67.04)
DDR_DQM1: length 46.2
  TOP w0.076: v1(98.76,61.44) U31.B3
  BOTTOM w0.076: v1(98.76,61.44) 99.03,61.44 99.16,61.56 99.16,62.46 99.29,62.58 100.14,62.58
  BOTTOM w0.121: 100.14,62.58 100.26,62.58 100.38,62.46 100.38,58.9 100.51,58.77 102.15,58.77 102.27,58.9 102.27,60.62 102.4,60.74 102.59,60.74 102.72,60.62 102.72,58.9 102.84,58.77 103.03,58.77 103.16,58.9 103.16,67.03 103.03,67.16 102.53,67.16 102.4,67.28 102.4,67.79 102.21,67.98 100.75,67.98 100.74,67.99 100.73,67.99 100.02,68.71 96.15,68.71 95.86,68.42 94.59,68.42 93.63,68.42 92.6,68.42 91.97,69.05 91.05,69.05 88.75,69.05 88.6,69.2 87.53,69.2 87.36,69.03 87,69.03 86.39,69.64 85.32,69.64 85,69.96 R19.2
DDR_DQS0: length 37.8
  TOP w0.076: 77.78,59.16 76.66,59.16 U8.B7
  TOP w0.121: 77.78,59.16 77.91,59.03 77.91,57.36 78.16,57.11 78.16,56.36 78.28,56.23 79.16,56.23 79.29,56.11 79.29,55.6 79.41,55.47 79.82,55.47 80.3,55.95 80.3,61.76 80.62,62.07 80.62,65.04 80.44,65.22 80.44,65.28 80.43,65.29 80.43,65.75 79.98,66.2 v1(79.98,66.65) ; R17.2 93.57,71.5 93.18,71.11 93.18,68.99 91.92,67.74 v1(91.92,66.9)
  BOTTOM w0.121: v1(79.98,66.65) 81,67.66 85.79,67.66 86.43,67.03 88.6,67.03 89.03,66.59 90.59,66.59 90.66,66.52 91.54,66.52 v1(91.92,66.9)
DDR_DQS1: length 42.6
  TOP w0.121: U31.B7 98.21,58.64 98.08,58.76 98.08,59.03 98.21,59.16 101.57,59.16 101.7,59.03 101.7,56.36 101.83,56.23 103.17,56.23 103.3,56.36 103.3,62.15 103.7,62.55 103.74,62.55 103.87,62.68 103.87,66.78 103.74,66.91 102.42,66.91 102.15,67.18 102.15,68.02 102.42,68.29 102.72,68.29 102.85,68.42 102.85,69.13 102.65,69.32 v1(102.65,69.76) ; v1(87.6,71.28) 87.86,71.54 R20.2
  BOTTOM w0.121: v1(87.6,71.28) 88,71.28 88.18,71.1 88.89,71.1 89.45,70.54 91.79,70.54 92.59,70.54 92.93,70.2 93.22,69.91 94.48,69.91 94.77,70.2 95.73,70.2 96.63,71.1 101.51,71.1 101.64,70.97 101.64,69.89 101.76,69.76 v1(102.65,69.76)
DDR_DQSN0: length 40.1
  TOP w0.076: 77.9,56.87 U8.A8
  TOP w0.121: R539.2 94.53,72.11 93.82,71.4 93.82,71.4 93.43,71 93.43,68.6 v1(92.43,67.6) ; 77.9,56.87 77.91,56.86 77.91,55.7 78.4,55.22 79.92,55.22 80.56,55.85 80.56,61.63 80.86,61.94 80.86,65.14 80.69,65.32 80.69,65.39 80.68,65.39 80.68,66.27 80.42,66.52 80.42,66.83 80.09,67.17 79.4,67.17 78.59,67.98 v1(78.58,67.98)
  BOTTOM w0.121: v1(78.58,67.98) 78.59,67.98 79.27,68.67 86.2,68.67 86.82,68.05 89.64,68.05 89.9,67.78 90.3,67.78 90.48,67.6 v1(92.43,67.6)
DDR_DQSN1: length 41.4
  TOP w0.121: v1(102.27,70.46) 102.96,70.46 103.1,70.32 103.1,68.17 102.97,68.04 102.53,68.04 102.4,67.92 102.4,67.28 102.53,67.16 103.99,67.16 104.11,67.03 104.11,62.43 103.99,62.31 103.8,62.31 103.55,62.05 103.55,56.11 103.42,55.98 101.45,55.98 101.32,56.11 101.32,58.71 101.19,58.84 100.39,58.84 100.27,58.71 100.27,58.09 100.01,57.84 v1(99.69,57.84) U31.A8 ; R540.2 89.05,72.11 89.29,71.87 v1(89.29,71.53)
  BOTTOM w0.121: v1(89.29,71.53) 89.29,71.12 89.63,70.79 92.69,70.79 93.18,70.3 93.32,70.15 94.38,70.15 94.67,70.45 95.62,70.45 96.52,71.35 101.76,71.35 101.89,71.22 101.89,70.59 102.02,70.46 v1(102.27,70.46)
DDR_ODT: length 65.1
  TOP w0.076: U31.F9 95.16,56.36 ; U8.F9 72.58,56.68 v1(72.49,56.68)
  TOP w0.121: v1(84.11,53.11) 84.11,53.69 84.34,53.92 84.72,53.92 85.91,55.11 85.91,56.66 86.13,56.89 86.13,61.71 87.38,62.96 87.38,65.82 87.19,66.01 87.19,66.56 83.86,69.89 83.86,70.97 83.35,71.47 82.78,71.47 R543.2 ; 95.16,56.36 v1(95.16,55.73)
  BOTTOM w0.121: v1(95.16,55.73) 95.91,55.73 96.11,55.52 96.11,54.33 95.99,54.2 95.6,54.2 95.48,54.08 95.48,50.71 95.35,50.58 84.94,50.58 84.81,50.71 84.81,52.87 84.57,53.11 v1(84.11,53.11) 83.71,53.11 83.41,52.81 83.41,51.47 83.29,51.35 71.73,51.35 71.6,51.47 71.6,56.55 71.73,56.68 v1(72.49,56.68)
DDR_RASN: length 63.5
  TOP w0.076: v1(72.54,59.04) U8.F7 ; v1(94.76,59.04) U31.F7
  LY3 w0.133: v1(79.73,73.82) 79.79,73.82 80.62,73 80.62,71.6 85.51,66.71 85.51,62.58 85.12,62.19 85.12,60.24 84.86,59.98 84.68,59.98 84.5,59.79 84.5,59.54 84.49,59.53 84.49,59.16 84.75,58.9 85.13,58.9 85.32,58.71 85.32,57.47 84.84,57 v1(84.49,57)
  BOTTOM w0.076: 77.91,57.7 77.12,57.7 76.05,58.77 73.89,58.77 73.76,58.9 73.76,60.15 73.63,60.27 72.24,60.27 72.11,60.15 72.11,59.16 72.24,59.04 v1(72.54,59.04) ; v1(94.76,59.04) 94.46,59.04 94.33,58.91 94.33,57.99 94.17,57.82 90.72,57.82 90.59,57.7 90.59,56.79
  BOTTOM w0.121: 84.49,57 v1(84.49,57) ; 84.49,57 84.49,57.19 84.37,57.32 83.99,57.32 83.79,57.12 83.61,57.12 83.41,57.32 83.16,57.32 83.04,57.2 83.04,56.92 82.92,56.8 82.68,56.8 82.56,56.92 82.56,57.2 82.44,57.32 82.2,57.32 82.08,57.2 82.08,56.92 81.96,56.8 81.72,56.8 81.6,56.92 81.6,57.2 81.48,57.32 81.23,57.32 81.11,57.2 81.11,56.92 80.99,56.8 80.75,56.8 80.63,56.92 80.63,57.2 80.51,57.32 80.27,57.32 80.15,57.2 80.15,56.92 80.03,56.8 79.79,56.8 79.67,56.92 79.67,57.2 79.55,57.32 79.3,57.32 79.18,57.2 79.18,56.92 79.06,56.8 78.58,56.8 78.33,57.05 78.33,57.5 78.13,57.7 77.91,57.7 ; 84.49,57 85.37,57 85.38,56.99 86.49,56.99 86.68,56.8 86.72,56.8 86.75,56.77 87.02,56.77 87.29,56.5 87.29,54.33 87.41,54.2 92.11,54.2 92.24,54.33 92.24,54.59 92.11,54.72 90.87,54.72 90.59,54.99 90.59,56.79 ; v1(79.73,73.82) 79.79,73.82 80.24,74.27 R14.2
DDR_VREF: length 67
  TOP w0.076: 95.16,65.16 95.16,63.61 95.29,63.49 95.4,63.49 95.96,62.93 U31.E2 v1(96.36,62.24) ; v1(74.14,62.24) U8.E2 73.75,62.64 74.21,63.09 74.21,64.81 74.08,64.93 73.06,64.93 72.94,65.06 72.94,65.16
  TOP w0.102: v2(84.2,80.2) U2.J4
  TOP w0.121: R542.2 94.28,66.96 94.28,66.91 95.16,66.03 95.16,65.16 ; 72.94,65.16 72.94,66.65 v1(73.44,67.16)
  BOTTOM w0.076: v1(74.14,62.24) 74.55,61.82 77.57,61.82 77.89,61.5 77.91,61.5 ; v1(96.36,62.24) 95.99,61.87 95.33,61.87 95.16,61.7 95.16,60.04 94.67,59.56 92.94,59.56 92.8,59.41 89.24,59.41
  BOTTOM w0.102: R541.2 84.59,80.2 v2(84.2,80.2) 83.94,80.2 83.52,80.62 81.19,80.62 80.43,81.38 79.7,81.38 79.53,81.21 77.96,81.21 77.19,80.44
  BOTTOM w0.121: 89.24,59.41 89.02,59.41 88.17,60.26 88.17,60.48 87.66,60.99 82.47,60.99 81.71,61.75 81.02,61.75 80.77,61.49 79.22,61.49 79.09,61.63 78.72,61.63 78.59,61.5 77.91,61.5 ; 77.19,80.44 77.18,80.44 76.84,80.09 76.36,80.09 76.16,79.9 74.06,79.9 74.01,79.85 72.79,79.85 71.6,78.67 71.6,77.88 72.23,77.25 72.23,74.27 71.83,73.86 71.83,68.77 v1(73.44,67.16)
DDR_WEN: length 60.6
  TOP w0.076: U31.F3 v1(95.56,61.44) ; v1(72.54,61.44) 72.49,61.39 72.49,60.87 72.59,60.77 73.55,60.77 73.66,60.87 73.66,61.06 73.53,61.19 73.06,61.19 72.94,61.31 U8.F3
  TOP w0.121: R15.2 73.57,71.56 75.37,69.77 77.47,69.77 79.67,67.56 79.82,67.42 80.19,67.42 80.67,66.93 80.67,66.63 81.57,65.73 81.57,65.32 81.55,65.31 81.55,61.25 81.32,61.01 v1(81.32,61)
  BOTTOM w0.076: v1(95.56,61.44) 95.73,61.44 95.83,61.33 95.83,59.5 95.73,59.4 94.61,59.4 94.46,59.26 94.26,59.26 94.11,59.4 93.81,59.4 93.66,59.26 93.46,59.26 93.31,59.4 93.01,59.4 92.73,59.12 92.73,58.88 92.51,58.67 92.18,58.67 92.11,58.74 91.78,58.74 91.71,58.67 91.24,58.67 91.11,58.79 91.11,59.09 90.98,59.22 89.83,59.22 89.7,59.09 89.7,57.43 89.59,57.31 89.3,57.31 ; 77.91,61.06 77.91,59.85 77.79,59.73 77.63,59.73 77.51,59.85 77.51,60.74 77.38,60.87 77.19,60.87 77.08,60.76 77.08,59.85 76.95,59.73 76.36,59.73 76.24,59.85 76.24,60.04 76.11,60.17 75.92,60.17 75.79,60.04 75.79,59.85 75.67,59.73 74.97,59.73 74.84,59.85 74.84,60.18 74.8,60.22 74.8,60.25 74.5,60.55 74.5,61.59 74.29,61.8 73.82,61.8 73.7,61.93 73.7,62.46 73.57,62.58 73.38,62.58 73.25,62.46 73.25,61.31 73.13,61.19 72.78,61.19 v1(72.54,61.44)
  BOTTOM w0.121: 77.91,61.06 78.04,61.19 78.28,61.19 78.52,60.94 78.52,60.35 78.7,60.17 79.16,60.17 79.29,60.3 79.29,60.87 79.42,61 80.04,61 80.17,60.87 80.17,60.55 80.3,60.43 80.49,60.43 80.62,60.55 80.62,60.87 80.75,61 v1(81.32,61) 81.32,60.56 81.44,60.43 86.97,60.43 87.55,59.86 88.22,59.86 88.55,59.53 88.55,59.25 89.13,58.68 89.13,57.49 89.3,57.31
EMU2: length 53.9
  TOP w0.121: R76.1 66.18,94.02 65.73,94.46 64.94,94.46 64.12,95.29 60.34,95.29 59.49,94.44 57.37,94.44 56.03,93.11 48.22,93.11 47.24,92.13 32.7,92.13 31.75,91.19 27.94,91.19 26.58,89.83 21.63,89.83 v1(21.12,89.32) ; 24,86.65 v1(22.14,86.65)
  BOTTOM w0.121: v1(21.12,89.32) 21.12,87.13 21.6,86.65 v1(22.14,86.65)
EMU3: length 40.2
  TOP w0.121: J2.18 31.66,86.65 32.04,87.03 32.04,89.78 33.27,91 35.21,91 35.62,90.59 46.9,90.59 48.68,92.37 57.23,92.37 57.31,92.45 61.59,92.45 62.71,93.57 63.48,93.57 R77.1
EMU4: length 62.5
  TOP w0.121: R78.1 70.75,91.22 70.05,91.93 68.48,91.93 67.66,92.75 65.65,92.75 64.96,93.44 64.57,93.44 63.86,94.14 62.39,94.14 61.31,93.06 59.73,93.06 59.22,93.57 57.19,93.57 56.24,92.61 48.55,92.61 47.19,91.25 32.96,91.25 31.53,89.83 27.47,89.83 26.2,88.56 20.87,88.56 v1(20.1,89.32) ; 24,85.38 v1(22.14,85.38)
  BOTTOM w0.121: v1(22.14,85.38) 21.37,85.38 20.1,86.65 v1(20.1,89.32)
EMU_RSTN: length 6.4
  TOP w0.121: R517.1 v1(22.14,87.92) 24,87.92
  BOTTOM w0.121: v1(22.14,87.92) 22.77,87.92 23.15,87.54 23.15,87.03 23.53,86.65 C260.1
ENZ_KALDO_1P8V: length 9.6
  TOP w0.102: U2.B4 78.64,80.24 78.64,79.72 78.33,79.41 77.76,79.41 77.34,79.83
  TOP w0.121: 77.34,79.83 76.63,79.83 75.97,79.17 72,79.17 R48.2
ETH_INTN: length 116.8
  TOP w0.121: v1(32.35,98.54) 34.3,98.54 34.5,98.34 42.38,98.34 43.12,99.07 47.69,99.07 49.39,100.77 50.3,100.77 51.42,101.89 v1(63.05,101.89) ; v1(64.24,108.19) 66.08,108.19 66.59,108.7 78.56,108.7 80.01,107.25 80.01,106.37 80.91,105.47 80.91,103.57 R404.1 ; U25.5 28.99,55.76 v1(28.85,55.89)
  BOTTOM w0.121: v1(28.85,55.89) 28.52,55.89 28.34,55.71 28.33,55.71 28.15,55.54 27.01,55.54 26.5,56.04 26.5,57.01 25.88,57.63 25.88,58.54 25.59,58.84 R409.1 24.8,58.08 23.53,58.08 23.15,58.46 23.15,61.38 22.39,62.14 22.39,63.34 22.5,63.46 22.5,64.64 24.05,64.64 24.05,64.66 26.9,67.51 26.9,81.74 32.32,87.16 32.32,91.73 32.4,91.8 32.4,98.05 32.35,98.1 v1(32.35,98.54) ; v1(64.24,108.19) 64.24,107.75 64.17,107.68 64.17,102.53 63.54,101.89 v1(63.05,101.89)
ETH_MDIO_CLK: length 134
  TOP w0.121: v1(91.35,99.22) 91.1,98.97 R433.1 ; v1(29.65,58.1) 30.09,57.67 30.09,57.38 U25.1
  LY3 w0.133: v1(92.62,111.52) 90.26,111.52 89.02,112.75 87.73,112.75 87.34,112.37 86.99,112.37 86.22,111.59 52.23,111.59 51.93,111.9 46.98,111.9 42.62,107.54 34.29,107.54 34.16,107.67 33.38,107.67 v1(33.11,107.4)
  BOTTOM w0.121: v1(29.65,58.1) 29.63,58.1 29.08,58.65 28.68,58.65 28.22,59.11 28.22,59.48 R407.2 27.72,81.72 32.82,86.82 32.82,91.47 32.9,91.55 32.9,97.83 33.03,97.96 33.03,99.04 33.56,99.57 33.56,106.95 v1(33.11,107.4) ; v1(92.62,111.52) 92.62,112 92.49,112.13 92.11,112.13 91.98,112 91.98,110.85 92.1,110.73 92.75,110.73 92.87,110.61 92.87,110.37 92.75,110.25 92.1,110.25 91.98,110.13 91.98,109.29 92.98,108.29 92.98,102.59 92.46,102.07 92.46,102.07 91.71,101.31 91.71,99.58 91.66,99.54 91.66,99.54 v1(91.35,99.22)
ETH_MDIO_DATA: length 134.6
  TOP w0.121: v1(30.53,60.08) 30.77,59.84 30.77,59.04 30.98,58.83 U25.48 ; R434.1 v1(93.68,100.88)
  LY3 w0.133: v1(95.92,111.04) 95.47,111.04 95.42,110.98 90.05,110.98 89.75,110.68 84.64,110.68 84.34,110.98 60.79,110.98 60.29,110.48 60.21,110.48 59.67,109.94 50.28,109.94 47.56,107.23 v1(33.97,107.23)
  BOTTOM w0.121: v1(30.53,60.08) 30.9,60.44 R408.1 28.54,63.36 28.54,82.08 33.15,86.7 33.15,97.6 33.28,97.73 33.28,98.54 33.97,99.23 v1(33.97,107.23) ; v1(93.68,100.88) 93.99,100.88 96.86,103.75 96.86,109.99 96.73,110.12 96.46,110.12 96.33,109.99 96.33,107.86 96.2,107.73 95.8,107.73 95.67,107.86 95.67,110.78 v1(95.92,111.04)
ETH_RBIAS: length 4.6
  TOP w0.121: v1(28.36,54.52) 28.76,54.11 29.46,54.11 29.51,54.16 U25.9
  BOTTOM w0.381: v1(28.36,54.52) 28.36,55 28.68,55.32 29.09,55.32 29.43,55.66 R406.2
ETH_REFCLK: length 148.7
  TOP w0.121: v1(37.12,52.74) 37.1,52.74 36.92,52.91 36.92,52.91 36.87,52.96 U25.25 ; v1(41.34,110.07) 39.38,110.07 38.77,109.46 38.77,105.5 39.25,105.02 50.57,105.02 50.7,105.14 50.7,107.53 50.83,107.66 51.31,107.66 51.67,108.02 51.67,109.28 51.8,109.41 65.7,109.41 65.91,109.62 78.94,109.62 80.45,108.11 R432.1
  BOTTOM w0.121: v1(41.34,110.07) 41.34,110.03 41.03,109.73 41.03,100.62 41.03,100.27 39.59,98.82 39.58,98.82 39.34,98.58 39.08,98.31 39.08,98.31 38.82,98.06 38.82,85.75 38.24,85.17 38.24,83.84 35.36,80.96 35.36,68.6 40.07,63.89 40.07,60.11 39.8,59.84 39.8,52.9 41.44,51.27 41.44,49.03 41.31,48.91 40.44,48.91 40.32,49.03 40.32,51.66 40.19,51.78 39.95,51.78 39.83,51.66 39.83,49.47 39.71,49.34 39.47,49.34 39.34,49.47 39.34,57.11 39.22,57.24 38.99,57.24 38.86,57.11 38.86,50.37 38.74,50.25 37.45,50.25 37.12,50.58 37.12,50.96 37.24,51.08 37.74,51.08 37.86,51.2 37.86,51.44 37.74,51.56 37.24,51.56 37.12,51.68 v1(37.12,52.74)
ETH_RESETN: length 7.3
  TOP w0.121: v1(29.22,57.52) 29.22,57.36 29.5,57.09 29.5,57.08 29.63,56.96 U25.2 ; U26.4 25.05,59.99 v1(25.18,59.85)
  BOTTOM w0.121: v1(29.22,57.52) 29.04,57.52 R391.1 27.15,59.41 25.71,59.41 25.65,59.47 25.56,59.47 v1(25.18,59.85)
ETH_RXCLK: length 5.9
  TOP w0.121: R423.1 R422.2 39.6,57.57 38.24,57.57 37.86,57.19 37.86,56.64 37.33,56.11 36.81,56.11 36.77,56.16 U25.33
ETH_RXD0: length 5.1
  TOP w0.121: R424.1 R411.2 39.59,55.02 38.78,55.02 38.74,54.98 38.07,54.98 37.69,55.36 U25.31
ETH_RXD1: length 5.2
  TOP w0.121: R425.1 R413.2 39.6,54.77 38.88,54.77 38.84,54.73 37.75,54.73 37.4,55.08 36.9,55.08 36.78,54.96 U25.30
ETH_RXD2: length 5.2
  TOP w0.121: U25.28 36.86,54.16 36.9,54.11 37.43,54.11 37.93,53.61 39.5,53.61 R419.2 R427.1
ETH_RXD3: length 5.9
  TOP w0.121: R428.1 R426.2 39.75,52.08 39.75,52.1 39.56,52.29 38.34,52.29 37.54,53.08 37.54,53.58 37.31,53.81 36.92,53.81 36.86,53.76 U25.27
ETH_RXDV: length 5.2
  TOP w0.121: R430.1 R414.2 39.39,56.09 37.84,56.09 37.5,55.76 U25.32
ETH_TXCLK: length 137.8
  TOP w0.121: U25.35 36.8,56.96 36.99,57.14 36.99,57.75 37.12,57.87 37.55,57.87 37.68,58 37.68,58.39 37.85,58.55 37.85,59.86 38.09,60.1 40.4,60.1 40.52,60.22 40.52,60.57 40.4,60.69 38.95,60.69 38.87,60.77 38.87,61.23 39,61.35 40.63,61.35 40.75,61.48 40.75,62.01 40.63,62.14 37.4,62.14 37.27,62.01 37.27,59.96 37.43,59.8 37.43,59.5 37.27,59.35 v1(37.27,58.86) ; v1(87.16,112.81) 86.29,112.81 86.12,112.64 82.48,112.64 81.57,113.55 61.54,113.55 61.07,113.07 51.71,113.07 51.37,112.74 45.55,112.74 45.43,112.86 45.43,112.97 45.31,113.09 45.07,113.09 44.95,112.97 44.95,112.86 44.83,112.74 44.59,112.74 44.47,112.86 44.47,112.97 44.35,113.09 44.1,113.09 43.98,112.97 43.98,112.86 43.86,112.74 43.62,112.74 43.5,112.86 43.5,112.97 43.38,113.09 43.14,113.09 43.02,112.97 43.02,112.86 42.9,112.74 42.13,112.74 41.83,113.04 v1(41.39,113.04)
  BOTTOM w0.121: R415.1 86.88,102.7 87.03,102.85 87.03,112.25 87.16,112.38 v1(87.16,112.81) ; v1(41.39,113.04) 40.78,112.43 40.78,112.4 40.35,111.97 40.35,111.44 39.89,110.98 39.89,101.2 37.7,99.01 37.7,98.87 37.72,98.85 37.72,86.31 36.84,85.43 36.84,84.37 33.9,81.43 33.9,69.28 33.78,69.16 33.78,68.79 33.82,68.75 33.82,68.44 38.98,63.28 38.98,60.77 38.53,60.32 38.53,60.12 v1(37.27,58.86)
ETH_TXD0: length 141
  TOP w0.121: v1(85.13,102.27) 85.53,101.87 85.53,100.77 86.19,100.11 R416.1 ; v1(85.2,116.14) 83.01,116.14 82.46,115.59 65.01,115.59 64.97,115.63 64.88,115.63 64.01,116.51 44.9,116.51 43.61,115.22 43.34,115.22 43.34,115.22 42,115.22 41.87,115.1 41.87,114.56 41.75,114.44 41.51,114.44 41.39,114.56 41.39,115.1 41.27,115.22 41.03,115.22 40.91,115.1 40.91,114.56 40.79,114.44 40.55,114.44 40.43,114.56 40.43,115.77 40.32,115.88 39.76,115.88 39.64,115.75 v1(39.64,113.78) ; v1(36.26,57.87) U25.36
  BOTTOM w0.121: v1(85.2,116.14) 85.2,115.17 85.43,114.95 85.43,104.9 85.3,104.77 85.25,104.77 85.13,104.64 v1(85.13,102.27) ; v1(39.64,113.78) 39.95,114.09 39.95,114.47 40.74,115.26 41.38,115.26 41.62,115.02 41.62,114.29 41.44,114.11 40.96,114.11 40.42,113.56 40.39,113.56 40.1,113.27 40.1,112.68 39.46,112.04 39.46,111.5 38.82,110.87 38.82,101.64 37,99.82 37,98.39 37,87.59 36.17,86.76 36.17,84.64 33.02,81.5 33.02,81.04 33.04,81.02 33.04,79.95 32.92,79.83 32.56,79.83 32.44,79.71 32.44,79.47 32.56,79.35 32.92,79.35 33.04,79.23 33.04,78.98 32.92,78.86 32.56,78.86 32.44,78.74 32.44,78.5 32.56,78.38 32.92,78.38 33.04,78.26 33.04,78.02 32.92,77.9 32.56,77.9 32.44,77.78 32.44,77.54 32.56,77.42 32.88,77.42 33.01,77.29 33.01,76.22 32.88,76.09 32.73,76.09 32.6,75.97 32.6,75.74 32.73,75.61 32.92,75.61 33.04,75.49 33.04,67.19 35.62,64.61 36.33,64.61 36.83,64.11 37.76,63.18 37.76,61.16 36.29,59.7 36.29,58.93 36.26,58.9 v1(36.26,57.87)
ETH_TXD1: length 138.6
  TOP w0.121: R417.1 88.49,99.56 v1(89.15,100.22) ; v1(39.66,112.86) 40.48,112.04 64.72,112.04 65.54,112.86 69.67,112.86 69.68,112.87 70.04,112.87 70.05,112.86 79.51,112.86 80.62,111.76 86.36,111.76 86.55,111.95 87.52,111.95 87.62,112.05 88.05,112.05 88.4,112.41 89.29,112.41 89.47,112.23 v1(89.47,111.44) ; U25.37 35.6,58.23 35.85,58.48 v1(35.85,59.12)
  BOTTOM w0.121: v1(89.47,111.44) 89.47,111 89.62,110.85 89.62,106.39 89.16,105.93 89.16,100.77 89.15,100.77 v1(89.15,100.22) ; v1(39.66,112.86) 39.04,112.24 39.04,111.68 38.4,111.04 38.4,106.65 38.28,106.53 37.27,106.53 37.15,106.41 37.15,106.17 37.27,106.05 38.28,106.05 38.4,105.93 38.4,105.68 38.28,105.56 36.95,105.56 36.83,105.44 36.83,105.2 36.95,105.08 38.28,105.08 38.4,104.96 38.4,104.72 38.28,104.59 36.95,104.59 36.83,104.47 36.83,104.23 36.95,104.11 38.28,104.11 38.4,103.99 38.4,103.75 38.28,103.63 36.95,103.63 36.83,103.51 36.83,103.27 36.95,103.15 38.28,103.15 38.4,103.03 38.4,102.78 38.28,102.66 37.93,102.66 37.81,102.54 37.81,102.31 37.93,102.18 38.28,102.18 38.4,102.06 38.4,101.81 36.58,99.99 36.58,87.77 35.74,86.93 35.74,84.82 32.02,81.09 32.02,67.61 35.2,64.43 35.44,64.18 36.15,64.18 36.4,63.93 37.29,63.04 37.29,61.3 35.85,59.86 v1(35.85,59.12)
ETH_TXD2: length 138.6
  TOP w0.121: U25.38 34.98,58.86 v1(35.22,59.09) ; v1(88.71,111.61) 87.79,111.61 87.69,111.52 86.91,111.52 86.72,111.33 80.24,111.33 79.83,111.75 65.02,111.75 64.9,111.62 39.52,111.62 39.04,112.1 v1(38.59,112.1) ; R418.1 89.45,99.1 v1(89.19,99.35)
  BOTTOM w0.121: v1(35.22,59.09) 35.22,61.28 35.37,61.43 35.65,61.43 35.99,61.09 36.47,61.09 36.87,61.49 36.87,62.87 35.98,63.76 35.27,63.76 34.77,64.25 31.13,67.9 31.13,68.23 31.01,68.35 30.91,68.35 30.79,68.47 30.79,68.71 30.91,68.84 31.01,68.84 31.13,68.96 31.13,69.2 31.01,69.32 30.91,69.32 30.79,69.44 30.79,69.68 30.91,69.8 31.01,69.8 31.13,69.92 31.13,70.16 31.01,70.28 30.91,70.28 30.79,70.4 30.79,70.64 30.91,70.77 31.01,70.77 31.13,70.89 31.13,71.13 31.01,71.25 30.91,71.25 30.79,71.37 30.79,71.61 30.91,71.73 31.01,71.73 31.13,71.85 31.13,72.09 31.01,72.21 30.91,72.21 30.79,72.33 30.79,72.58 30.91,72.7 31.01,72.7 31.13,72.82 31.13,73.06 31.01,73.18 30.91,73.18 30.79,73.3 30.79,73.54 30.91,73.66 31.01,73.66 31.13,73.78 31.13,74.02 31.01,74.14 30.91,74.14 30.79,74.26 30.79,74.51 30.91,74.63 31.01,74.63 31.13,74.75 31.13,74.99 31.01,75.11 30.91,75.11 30.79,75.23 30.79,75.47 30.91,75.59 31.01,75.59 31.13,75.71 31.13,75.95 31.01,76.07 30.91,76.07 30.79,76.19 30.79,76.44 30.91,76.56 31.01,76.56 31.13,76.68 31.13,76.92 31.01,77.04 30.91,77.04 30.79,77.16 30.79,77.4 30.91,77.52 31.01,77.52 31.13,77.64 31.13,77.89 31,78.02 30.85,78.02 30.72,78.14 30.72,78.47 30.85,78.6 31,78.6 31.13,78.73 31.13,82.92 31.33,83.12 31.5,83.12 32.31,82.32 32.48,82.32 32.65,82.49 32.65,82.66 31.84,83.47 31.84,83.64 32.02,83.81 32.19,83.81 32.99,83 33.16,83 33.34,83.17 33.34,83.34 32.53,84.15 32.53,84.32 32.7,84.49 32.87,84.49 33.68,83.68 33.85,83.68 34.02,83.85 34.02,84.02 33.21,84.83 33.21,85 33.44,85.23 33.59,85.23 33.74,85.08 33.92,85.08 34.08,85.24 34.08,85.42 33.89,85.61 33.89,85.68 36.15,87.94 36.15,101.85 36.4,102.09 36.4,106.67 37.97,108.24 37.97,111.28 38.28,111.59 38.28,111.79 v1(38.59,112.1) ; v1(88.71,111.61) 88.71,110.68 89.17,110.22 89.17,106.74 88.71,106.29 88.71,99.83 v1(89.19,99.35)

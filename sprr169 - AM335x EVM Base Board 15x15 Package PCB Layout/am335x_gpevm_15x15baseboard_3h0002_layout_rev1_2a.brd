# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_2a.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TP36  TP1mm  [TP_SMD1MMCIRCLE]  91.35 96.3 0 top
TP38  TP1mm  [TP_SMD1MMCIRCLE]  43.47 61.38 0 top
TP39  TP1mm  [TP_SMD1MMCIRCLE]  43.47 59.98 0 top
TP40  TP1mm  [TP_SMD1MMCIRCLE]  43.47 57.82 0 top
TP41  TP1mm  [TP_SMD1MMCIRCLE]  43.47 56.43 0 top
TP42  TP1mm  [TP_SMD1MMCIRCLE]  14.64 112.94 180 bottom
TP43  TP1mm  [TP_SMD1MMCIRCLE]  13.5 113.58 180 bottom
TP44  TP1mm  [TP_SMD1MMCIRCLE]  14.77 114.21 180 bottom
TP45  TP1mm  [TP_SMD1MMCIRCLE]  3.47 137.45 180 bottom
TP46  TP1mm  [TP_SMD1MMCIRCLE]  31.91 64.43 0 top
TP47  TP1mm  [TP_SMD1MMCIRCLE]  33.18 64.43 0 top
TP48  TP1mm  [TP_SMD1MMCIRCLE]  34.45 64.43 0 top
TP49  TP1mm  [TP_SMD1MMCIRCLE]  35.72 64.43 0 top
TP50  TP1mm  [TP_SMD1MMCIRCLE]  36.36 51.22 180 bottom
U1  SN74AUP1G08  [U_5_DCK]  56.43 100.57 90 top
U2  AM335X_15x15  [AM33XX_15X15]  85 85 90 top
U3  SN74AUP1G08  [U_5_DCK]  62.9 100.11 90 top
U4  TPS65910  [U_48_RSL]  89.45 33.69 90 top
U5  TPS71718  [SMDSC70-5]  84.11 22.52 0 top
U6  SN74AUP2G08  [U_8_DCU]  90.21 23.53 270 top
U7  CAT24C256W  [SOIC_8]  140.31 67.89 0 top
U8  MT47H256M8  [DDR2_FBGA60PIN]  72.94 60.24 270 top
U9  MT29F2G08AB  [SKT-TSOP48SM]  149.01 106.59 90 top
U10  SIL9022A  [QFN_72]  140.88 33.44 180 top
U11  TPD12S016  [PW_24PIN_TSSOP]  140.5 15.02 270 top
U12  TPS71712  [SMDSC70-5]  148.63 18.83 180 top
U13  SN74AVC4T245  [U_16_PW]  23.28 118.4 90 top
U14  SN74AVC4T245  [U_16_PW]  23.28 124.75 90 top
U15  SN74AVC4T245  [U_16_PW]  23.28 137.45 90 top
U16  SN74AVC4T245  [U_16_PW]  23.28 131.1 90 top
U17  TPS79501  [SOT223_6PIN]  8.55 101.64 90 top
U18  MAX3232E  [U_16_D]  109.51 18.58 270 top
U19  TPD6E001  [U_10_RSE]  58.46 144.06 0 top
U20  TPD6E001  [U_10_RSE]  71.92 149.77 90 top
U21  TPD2E001  [U_5_DRL]  64.93 144.56 270 top
U22  TPS2051BD  [U_8_D]  135.42 147.55 0 top
U23  TPD4S012  [U_6_DRY]  132.37 162.32 0 top
U24  TPS63010  [U_20_DSBGA]  155.99 146.85 90 top
U25  AR8031_AL1A  [QFN48]  33.18 55.16 0 top
U26  SN74LVC1G07  [U_6_DCK]  24.17 61.51 90 top
U27  INA226  [SMDMSOP_10]  69.13 47.03 270 bottom
U28  TXS02612  [U_24_RTW]  23.02 108.62 270 top
U29  TPS2051BD  [U_8_D]  143.74 147.23 0 top
U30  TPD4S012  [U_6_DRY]  147.93 161.45 0 top
U31  MT47H256M8  [DDR2_FBGA60PIN]  95.16 60.24 270 top
U32  INA226  [SMDMSOP_10]  64.36 35.15 270 top
U33  SN74AVC1T45  [SMDSC70-6]  60.87 105.27 90 top
Y1  32.768KHz MC-306  [MC-306]  63.03 76.36 270 top
Y2  24MHz  [SM_CRY_SCC18]  105.7 81.83 0 top
Y3  25MHz  [SM_OSC_ABM3]  24.68 56.17 270 top

## Library data of the parts
BT1 = Battery_coin3V
C1 C16 C17 C19 C23-C25 C29-C32 C35 C36 C43 C45-C48 C50 C52 C53 C61 C62 = 0.01uFCapacitor16V10%0402
C2 C3 = 25pFCapacitor100V5%0603
C4 C5 = 18pFCapacitor16V10%0402
C6-C8 C15 C27 C28 C34 C41 C42 C56 C63 C64 C66-C70 C73 C74 C76-C80 C82 C83 C87 C89 C90 C92-C94 C96 C98 C111 C114-C116 C125 C126 C128-C130 C136-C140 C149 C155-C158 C161-C170 C174 C175 C181 C183 C186 C188 C189 C195 C202 C213-C222 = 0.01uFCapacitor16V10%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C9 = 0.1uFCapacitor16V10%0402
C10 C12 = 0.001uFCapacitor50V5%0402
C11 C13 C85 C86 C127 C131-C135 C141-C148 C150-C154 C176-C180 C187 C190 C193 C194 C196-C201 C260 C264 = 0.1uFCapacitor16V10%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C14 = 0.001uFCapacitor50V5%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C60 = 1uFCapacitor16V10%0402
C65 C71 C72 C88 C112 C113 C117 C118 C159 C160 C173 C191 C192 = 1uFCapacitor16V10%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C84 = 100uFCapacitor16V20%ElectroPoly
C91 C97 C101-C104 C107-C110 C184 = 2.2uFCapacitor6.3V20%smdX5R0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C171 = 15pFCapacitor50V10%smd0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C172 = 2.2uF16V10%SMD0805
C182 C185 = 150uFCapacitor10V10%2917
C204 C212 = 22pFCapacitor50V10%SMD0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C205-C207 = 470pFCapacitor25V10%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
C232-C249 C256-C259 C261 C273 C274 = 10uFCapacitor16V10%0805
C250-C255 = 4.7uFCapacitor6.3V20%smdX5R0603
C262 C263 C265 = 4.7uFCapacitor16V10%0603
C266-C270 = 22uFCapacitor16V10%0805
C271 C272 = 0.1uFCapacitor50V10%0402: Tolerance: TOLERANCE; User Part Number: USERPART#
D1 = Diode_5ARect
D2 = Diode_SMCJ15CA
D3-D7 = LED_Green
D8 = Diode200mA250V
D9 D10 = Diode_Zener_5.1V_100mW
F1 = Fuse_4A
FB1-FB14 FB19-FB21 = FerBead_180ohm200mA
FB15 FB16 = FerriteBead_600mA10ohm
FB17 = FerriteEMI600ohm500mAsmd0603
J1 = Conn_PwrJack_RAPC712
J2 = Header10x2_CJTAG
J3 J4 J6 J16 = Header_28pin_0.1in
J5 = Header_40pin_0.1in
J7-J9 = Header10x2_0.5inpitch_female
J10 = Conn_HDMI_TypeA
J11 = Conn_SamtecMEC6_150
J12 = Conn_DSUB9M_TH
J13 = Conn_SDCard_MHC-W21-601
J14 = Conn_MicroUSBAB
J15 = ConnectorRJ45_Gigabit
J17 = Header_5x1
J18 = Connector_USB_A
J19 = Header20x1_wkey
J20-J39 = Header_2x1
L2-L4 = 2.2uHInductor10%2.6Asmd
L5 L6 = ACM2012
L7 L8 = 4.7uH30%0.9Asmd
L9 = 4.7uHInductor30%3.1Asmd
Q1-Q4 = MOSFET_NChan_BSS138
Q5 = MOSFET_PChan_BSS84
R1 R3 R5 R8 R10 R30 R45 R51 R53 R55-R64 R66 R68 R73-R78 R84 R85 R87-R92 R113 R133-R157 R159 R161 R163 R165 R167 R169 R171 R173 R175-R184 R186 R187 R189 R191 R193 R194 R196-R230 R232-R234 R236 R240-R273 R278-R291 R293-R303 R305 R307 R308 R311-R325 R327 R328 R335-R358 R361-R364 R379 R380 R384 R385 R388 R389 R396-R401 R404 R405 R410 R423-R425 R427 R428 R430 R436-R452 R456-R460 R478 R479 R485-R492 R509-R512 R516 R550 R551 R556 R559-R562 R566 R571 = ZeroOhmResistor1/16W0402
R4 R86 R93-R111 R386 R391 = 100KOhmResistor1/16W0402
R6 R48 R54 R65 R72 R114-R132 R239 R274 R304 R306 R329-R334 R365-R373 R382 R383 R387 R393 R407 R409 R411-R414 R419 R422 R426 R431 R435 R455 R515 R518 R519 R544 R565 R569 R570 = 10KOhmResistor1/16W0402
R7 = 1MOhmResistor1/16W0402
R11-R21 R31 R33-R44 R47 R49 R429 R522-R540 R543 R549 = 22OhmResistor1/16W1%0402: signal model: 33OHMRESISTOR1_16W5_0402_SM_735_33
R22 = 50OhmResistor1/16W1%0402
R23 = 124Kohm1/16W1%SMD0402
R32 R46 = 0.05ohm0.5W1%Sense1206
R50 R80-R83 = 150ohm1/16W1%SMD0402
R69 R112 = 1KOhmResistor1/16W0402
R70 R71 R79 R275 R276 R326 R394 R453 R454 R547 R548 R552-R555 = 4.7KOhmResistor1/16W0402
R188 R231 R235 R237 R395 R415-R418 R420 R421 R432-R434 = 22OhmResistor1/16W1%0402
R277 = 51Kohm1/16W1%smd0402
R292 = 4.3KOhmResistor1/16W0402
R359 = 57.6Kohm1/10W1%smd0402
R360 = 30.1Kohm1/16W1%smd0402
R378 = 470Kohm1/16W1%SMD0402
R381 = 120Kohm1/16W1%SMD0402
R390 R392 = 220ohm1/10W1%smd0402
R406 = 2.37KOhmResistor1/16W1%0402
R408 = 1.5KohmResistor1/16W5%smd0402
R461 R462 R517 = 100ohm1/16W1%SMD0402
R463-R477 R557 R558 = ZeroOhmResistor1/16W0603
R493-R496 R498 R508 R545 R546 = 0.24ohm0.25W1%Sense0805
R497 R499 R500 R503-R507 = 2ohm0.25W1%Sense0805
R501 R502 = 1ohm0.25W1%Sense0805
R520 = 1.62MOhmResistor1/16W0402
R521 = 180KOhmResistor1/16W0402
R541 R542 R567 R568 = 2.2KOhmResistor1/16W0402
R563 R564 = 1.2KohmResistor1/4W5%0805
SW1 = Switch_SlideRA_SPDT
SW2 SW5 = Switch_Pushbuttonsmd
SW3 SW4 = SwitchDIP8pos_smd
TP2 TP23 TP24 TP31 TP32 TP35 TP36 TP38-TP50 = Testpoint_SMD1mmCircle
TP25-TP30 = TestPointThroughHole
U1 U3 = SN74AUP1G08
U2 = AM335X_15mmx15mm
U4 = TPS65910
U5 = TPS71718
U6 = SN74AUP2G08
U7 = CAT24C256W
U8 U31 = MT47H256M8
U9 = MT29F2G08ABBE
U10 = SIL9022A
U11 = TPD12S016
U12 = TPS71712
U13-U16 = SN74AVC4T245
U17 = TPS79501
U18 = MAX3232E
U19 U20 = TPD6E001RSE
U21 = TPD2E001DRL
U22 U29 = TPS2051BD
U23 U30 = TPD4S012
U24 = TPS63010YFF
U25 = AR8031-AL1A_QFN48
U26 = SN74LVC1G07
U27 U32 = INA226
U28 = TXS02612
U33 = SN74AVC1T45
Y1 = Crystal_SMD32_768kHz
Y2 = Crystal24MHzSCC
Y3 = Crystal25MHzABM3

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
219-8MST
  rect 1.118x2.438 smd: 1(-8.89,-4.318) 2(-6.35,-4.318) 3(-3.81,-4.318) 4(-1.27,-4.318) 5(1.27,-4.318) 6(3.81,-4.318) 7(6.35,-4.318) 8(8.89,-4.318) 9(8.89,4.318) 10(6.35,4.318) 11(3.81,4.318) 12(1.27,4.318) 13(-1.27,4.318) 14(-3.81,4.318) 15(-6.35,4.318) 16(-8.89,4.318)
6605814-6
  round 1.422 hole 0.889: 1(0,0) 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.397 hole 1.016: D1(-1.067,-11.43) D2(-1.067,-13.462) D3(12.497,-11.43) D4(12.497,-13.462)
  round 3.81 hole 3.175: M1(0,-8.89) M2(11.43,-8.89)
  round 2.159 hole 1.575: SHLD1(-2.032,-5.842) SHLD2(13.462,-5.842)
ACM2012H
  rect 0.75x0.35 smd: 1(-0.975,0.425) 2(-0.975,-0.425) 3(0.975,-0.425) 4(0.975,0.425)
AM33XX_15X15
  round 1.27 hole 1.778 unplated: (-9.238,8.863) (-9.238,-8.862) (8.487,8.863) (8.487,-8.862)
  round 1.397 hole 0.838 unplated: (-9.238,-3.782) (8.487,6.323)
  round 0.356 smd: A1(-6.8,6.8) A2(-6,6.8) A3(-5.2,6.8) A4(-4.4,6.8) A5(-3.6,6.8) A6(-2.8,6.8) A7(-2,6.8) A8(-1.2,6.8) A9(-0.4,6.8) A10(0.4,6.8) A11(1.2,6.8) A12(2,6.8) A13(2.8,6.8) A14(3.6,6.8) A15(4.4,6.8) A16(5.2,6.8) A17(6,6.8) A18(6.8,6.8) B1(-6.8,6) B2(-6,6) B3(-5.2,6) B4(-4.4,6) B5(-3.6,6) B6(-2.8,6) B7(-2,6) B8(-1.2,6) B9(-0.4,6) B10(0.4,6) B11(1.2,6) B12(2,6) B13(2.8,6) B14(3.6,6) B15(4.4,6) B16(5.2,6) B17(6,6) B18(6.8,6) C1(-6.8,5.2) C2(-6,5.2) C3(-5.2,5.2) C4(-4.4,5.2) C5(-3.6,5.2) C6(-2.8,5.2) C7(-2,5.2) C8(-1.2,5.2) C9(-0.4,5.2) C10(0.4,5.2) C11(1.2,5.2) C12(2,5.2) C13(2.8,5.2) C14(3.6,5.2) C15(4.4,5.2) C16(5.2,5.2) C17(6,5.2) C18(6.8,5.2) D1(-6.8,4.4) D2(-6,4.4) D3(-5.2,4.4) D4(-4.4,4.4) D5(-3.6,4.4) D6(-2.8,4.4) D7(-2,4.4) D8(-1.2,4.4) D9(-0.4,4.4) D10(0.4,4.4) D11(1.2,4.4) D12(2,4.4) D13(2.8,4.4) D14(3.6,4.4) D15(4.4,4.4) D16(5.2,4.4) D17(6,4.4) D18(6.8,4.4) E1(-6.8,3.6) E2(-6,3.6) E3(-5.2,3.6) E4(-4.4,3.6) E5(-3.6,3.6) E6(-2.8,3.6) E7(-2,3.6) E8(-1.2,3.6) E9(-0.4,3.6) E10(0.4,3.6) E11(1.2,3.6) E12(2,3.6) E13(2.8,3.6) E14(3.6,3.6) E15(4.4,3.6) E16(5.2,3.6) E17(6,3.6) E18(6.8,3.6) F1(-6.8,2.8) F2(-6,2.8) F3(-5.2,2.8) F4(-4.4,2.8) F5(-3.6,2.8) F6(-2.8,2.8) F7(-2,2.8) F8(-1.2,2.8) F9(-0.4,2.8) F10(0.4,2.8) F11(1.2,2.8) F12(2,2.8) F13(2.8,2.8) F14(3.6,2.8) F15(4.4,2.8) F16(5.2,2.8) F17(6,2.8) F18(6.8,2.8) G1(-6.8,2) G2(-6,2) G3(-5.2,2) G4(-4.4,2) G5(-3.6,2) G6(-2.8,2) G7(-2,2) G8(-1.2,2) G9(-0.4,2) G10(0.4,2) G11(1.2,2) G12(2,2) G13(2.8,2) G14(3.6,2) G15(4.4,2) G16(5.2,2) G17(6,2) G18(6.8,2) H1(-6.8,1.2) H2(-6,1.2) H3(-5.2,1.2) H4(-4.4,1.2) H5(-3.6,1.2) H6(-2.8,1.2) H7(-2,1.2) H8(-1.2,1.2) H9(-0.4,1.2) H10(0.4,1.2) H11(1.2,1.2) H12(2,1.2) H13(2.8,1.2) H14(3.6,1.2) H15(4.4,1.2) H16(5.2,1.2) H17(6,1.2) H18(6.8,1.2) J1(-6.8,0.4) J2(-6,0.4) J3(-5.2,0.4) J4(-4.4,0.4) J5(-3.6,0.4) J6(-2.8,0.4) J7(-2,0.4) J8(-1.2,0.4) J9(-0.4,0.4) J10(0.4,0.4) J11(1.2,0.4) J12(2,0.4) J13(2.8,0.4) J14(3.6,0.4) J15(4.4,0.4) J16(5.2,0.4) J17(6,0.4) J18(6.8,0.4) K1(-6.8,-0.4) K2(-6,-0.4) K3(-5.2,-0.4) K4(-4.4,-0.4) K5(-3.6,-0.4) K6(-2.8,-0.4) K7(-2,-0.4) K8(-1.2,-0.4) K9(-0.4,-0.4) K10(0.4,-0.4) K11(1.2,-0.4) K12(2,-0.4) K13(2.8,-0.4) K14(3.6,-0.4) K15(4.4,-0.4) K16(5.2,-0.4) K17(6,-0.4) K18(6.8,-0.4) L1(-6.8,-1.2) L2(-6,-1.2) L3(-5.2,-1.2) L4(-4.4,-1.2) L5(-3.6,-1.2) L6(-2.8,-1.2) L7(-2,-1.2) L8(-1.2,-1.2) L9(-0.4,-1.2) L10(0.4,-1.2) L11(1.2,-1.2) L12(2,-1.2) L13(2.8,-1.2) L14(3.6,-1.2) L15(4.4,-1.2) L16(5.2,-1.2) L17(6,-1.2) L18(6.8,-1.2) M1(-6.8,-2) M2(-6,-2) M3(-5.2,-2) M4(-4.4,-2) M5(-3.6,-2) M6(-2.8,-2) M7(-2,-2) M8(-1.2,-2) M9(-0.4,-2) M10(0.4,-2) M11(1.2,-2) M12(2,-2) M13(2.8,-2) M14(3.6,-2) M15(4.4,-2) M16(5.2,-2) M17(6,-2) M18(6.8,-2) N1(-6.8,-2.8) N2(-6,-2.8) N3(-5.2,-2.8) N4(-4.4,-2.8) N5(-3.6,-2.8) N6(-2.8,-2.8) N7(-2,-2.8) N8(-1.2,-2.8) N9(-0.4,-2.8) N10(0.4,-2.8) N11(1.2,-2.8) N12(2,-2.8) N13(2.8,-2.8) N14(3.6,-2.8) N15(4.4,-2.8) N16(5.2,-2.8) N17(6,-2.8) N18(6.8,-2.8) P1(-6.8,-3.6) P2(-6,-3.6) P3(-5.2,-3.6) P4(-4.4,-3.6) P5(-3.6,-3.6) P6(-2.8,-3.6) P7(-2,-3.6) P8(-1.2,-3.6) P9(-0.4,-3.6) P10(0.4,-3.6) P11(1.2,-3.6) P12(2,-3.6) P13(2.8,-3.6) P14(3.6,-3.6) P15(4.4,-3.6) P16(5.2,-3.6) P17(6,-3.6) P18(6.8,-3.6) R1(-6.8,-4.4) R2(-6,-4.4) R3(-5.2,-4.4) R4(-4.4,-4.4) R5(-3.6,-4.4) R6(-2.8,-4.4) R7(-2,-4.4) R8(-1.2,-4.4) R9(-0.4,-4.4) R10(0.4,-4.4) R11(1.2,-4.4) R12(2,-4.4) R13(2.8,-4.4) R14(3.6,-4.4) R15(4.4,-4.4) R16(5.2,-4.4) R17(6,-4.4) R18(6.8,-4.4) T1(-6.8,-5.2) T2(-6,-5.2) T3(-5.2,-5.2) T4(-4.4,-5.2) T5(-3.6,-5.2) T6(-2.8,-5.2) T7(-2,-5.2) T8(-1.2,-5.2) T9(-0.4,-5.2) T10(0.4,-5.2) T11(1.2,-5.2) T12(2,-5.2) T13(2.8,-5.2) T14(3.6,-5.2) T15(4.4,-5.2) T16(5.2,-5.2) T17(6,-5.2) T18(6.8,-5.2) U1(-6.8,-6) U2(-6,-6) U3(-5.2,-6) U4(-4.4,-6) U5(-3.6,-6) U6(-2.8,-6) U7(-2,-6) U8(-1.2,-6) U9(-0.4,-6) U10(0.4,-6) U11(1.2,-6) U12(2,-6) U13(2.8,-6) U14(3.6,-6) U15(4.4,-6) U16(5.2,-6) U17(6,-6) U18(6.8,-6) V1(-6.8,-6.8) V2(-6,-6.8) V3(-5.2,-6.8) V4(-4.4,-6.8) V5(-3.6,-6.8) V6(-2.8,-6.8) V7(-2,-6.8) V8(-1.2,-6.8) V9(-0.4,-6.8) V10(0.4,-6.8) V11(1.2,-6.8) V12(2,-6.8) V13(2.8,-6.8) V14(3.6,-6.8) V15(4.4,-6.8) V16(5.2,-6.8) V17(6,-6.8) V18(6.8,-6.8)
B520C-13-F
  rect 2.5x3.3 smd: 1(-3.4,0) 2(3.4,0)
BLM18A
  rect 1.143x1.092 smd: 1(-0.9,0) 2(0.9,0)
CHKFOOTPRINT
  rect 0.8x1.8 smd: 1(-0.8,0) 2(0.8,0)
DDR2_FBGA60PIN
  round 0.356 smd: A1(-3.2,4) A2(-2.4,4) A3(-1.6,4) A7(1.6,4) A8(2.4,4) A9(3.2,4) B1(-3.2,3.2) B2(-2.4,3.2) B3(-1.6,3.2) B7(1.6,3.2) B8(2.4,3.2) B9(3.2,3.2) C1(-3.2,2.4) C2(-2.4,2.4) C3(-1.6,2.4) C7(1.6,2.4) C8(2.4,2.4) C9(3.2,2.4) D1(-3.2,1.6) D2(-2.4,1.6) D3(-1.6,1.6) D7(1.6,1.6) D8(2.4,1.6) D9(3.2,1.6) E1(-3.2,0.8) E2(-2.4,0.8) E3(-1.6,0.8) E7(1.6,0.8) E8(2.4,0.8) E9(3.2,0.8) F2(-2.4,0) F3(-1.6,0) F7(1.6,0) F8(2.4,0) F9(3.2,0) G1(-3.2,-0.8) G2(-2.4,-0.8) G3(-1.6,-0.8) G7(1.6,-0.8) G8(2.4,-0.8) H2(-2.4,-1.6) H3(-1.6,-1.6) H7(1.6,-1.6) H8(2.4,-1.6) H9(3.2,-1.6) J1(-3.2,-2.4) J2(-2.4,-2.4) J3(-1.6,-2.4) J7(1.6,-2.4) J8(2.4,-2.4) K2(-2.4,-3.2) K3(-1.6,-3.2) K7(1.6,-3.2) K8(2.4,-3.2) K9(3.2,-3.2) L1(-3.2,-4) L2(-2.4,-4) L3(-1.6,-4) L7(1.6,-4) L8(2.4,-4)
GMD2_2PIN
  rect 0.31x0.23 smd: 1(0,-0.19) 2(0,0.19)
HEADER10X2
  rect 0.711x2.87 smd: 1(-5.715,-2.705) 2(-5.715,2.705) 3(-4.445,-2.705) 4(-4.445,2.705) 5(-3.175,-2.705) 6(-3.175,2.705) 7(-1.905,-2.705) 8(-1.905,2.705) 9(-0.635,-2.705) 10(-0.635,2.705) 11(0.635,-2.705) 12(0.635,2.705) 13(1.905,-2.705) 14(1.905,2.705) 15(3.175,-2.705) 16(3.175,2.705) 17(4.445,-2.705) 18(4.445,2.705) 19(5.715,-2.705) 20(5.715,2.705)
HEADER20X1_0_100IN
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(2.54,0) 3(5.08,0) 5(10.16,0) 6(12.7,0) 7(15.24,0) 8(17.78,0) 9(20.32,0) 10(22.86,0) 11(25.4,0) 12(27.94,0) 13(30.48,0) 14(33.02,0) 15(35.56,0) 16(38.1,0) 17(40.64,0) 18(43.18,0) 19(45.72,0) 20(48.26,0)
HEADER_2X1
  rect 1.778x1.778 hole 1.016: 1(0,0)
  round 1.778 hole 1.016: 2(0,2.54)
HEADER_5X1
  rect 1.778x1.778 hole 1.016: 1(0,0)
  round 1.778 hole 1.016: 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0)
HEADER_10X2_TH
  oval 0.914x1.168 hole 0.66: 1(0,0) 2(0,1.27) 3(1.27,0) 4(1.27,1.27) 5(2.54,0) 6(2.54,1.27) 7(3.81,0) 8(3.81,1.27) 9(5.08,0) 10(5.08,1.27) 11(6.35,0) 12(6.35,1.27) 13(7.62,0) 14(7.62,1.27) 15(8.89,0) 16(8.89,1.27) 17(10.16,0) 18(10.16,1.27) 19(11.43,0) 20(11.43,1.27)
HF70ACB201209
  rect 1x1 smd: 1(-1,0) 2(1,0)
JUMP2X14-6040-1
  round 1.397 hole 1.016: 1(0,0) 2(0,2.54) 3(-2.54,0) 4(-2.54,2.54) 5(-5.08,0) 6(-5.08,2.54) 7(-7.62,0) 8(-7.62,2.54) 9(-10.16,0) 10(-10.16,2.54) 11(-12.7,0) 12(-12.7,2.54) 13(-15.24,0) 14(-15.24,2.54) 15(-17.78,0) 16(-17.78,2.54) 17(-20.32,0) 18(-20.32,2.54) 19(-22.86,0) 20(-22.86,2.54) 21(-25.4,0) 22(-25.4,2.54) 23(-27.94,0) 24(-27.94,2.54) 25(-30.48,0) 26(-30.48,2.54) 27(-33.02,0) 28(-33.02,2.54)
JUMP2X20-6040-1
  round 1.524 hole 1.016: 1(0,0) 2(0,2.54) 3(-2.54,0) 4(-2.54,2.54) 5(-5.08,0) 6(-5.08,2.54) 7(-7.62,0) 8(-7.62,2.54) 9(-10.16,0) 10(-10.16,2.54) 11(-12.7,0) 12(-12.7,2.54) 13(-15.24,0) 14(-15.24,2.54) 15(-17.78,0) 16(-17.78,2.54) 17(-20.32,0) 18(-20.32,2.54) 19(-22.86,0) 20(-22.86,2.54) 21(-25.4,0) 22(-25.4,2.54) 23(-27.94,0) 24(-27.94,2.54) 25(-30.48,0) 26(-30.48,2.54) 27(-33.02,0) 28(-33.02,2.54) 29(-35.56,0) 30(-35.56,2.54) 31(-38.1,0) 32(-38.1,2.54) 33(-40.64,0) 34(-40.64,2.54) 35(-43.18,0) 36(-43.18,2.54) 37(-45.72,0) 38(-45.72,2.54) 39(-48.26,0) 40(-48.26,2.54)
MC-306
  rect 1.3x1.9 smd: 1(-2.75,-1.6) 2(2.75,-1.6) 3(2.75,1.6) 4(-2.75,1.6)
MEC6-150-02-S-D-RA1
  round 0.254 hole 1.549 unplated: (-18.345,0) (18.345,0)
  rect 0.4x2 smd: 1(-17.145,-4) 2(-17.145,4) 3(-16.51,-4) 4(-16.51,4) 5(-15.875,-4) 6(-15.875,4) 7(-15.24,-4) 8(-15.24,4) 9(-14.605,-4) 10(-14.605,4) 11(-13.97,-4) 12(-13.97,4) 13(-13.335,-4) 14(-13.335,4) 15(-12.7,-4) 16(-12.7,4) 17(-12.065,-4) 18(-12.065,4) 19(-11.43,-4) 20(-11.43,4) 21(-10.795,-4) 22(-10.795,4) 23(-10.16,-4) 24(-10.16,4) 25(-9.525,-4) 26(-9.525,4) 27(-8.89,-4) 28(-8.89,4) 29(-8.255,-4) 30(-8.255,4) 31(-7.62,-4) 32(-7.62,4) 33(-6.985,-4) 34(-6.985,4) 35(-6.35,-4) 36(-6.35,4) 37(-5.715,-4) 38(-5.715,4) 39(-5.08,-4) 40(-5.08,4) 41(-4.445,-4) 42(-4.445,4) 43(-3.81,-4) 44(-3.81,4) 45(-3.175,-4) 46(-3.175,4) 47(-2.54,-4) 48(-2.54,4) 49(-1.905,-4) 50(-1.905,4) 51(-1.27,-4) 52(-1.27,4) 53(-0.635,-4) 54(-0.635,4) 55(0,-4) 56(0,4) 57(0.635,-4) 58(0.635,4) 59(1.27,-4) 60(1.27,4) 61(1.905,-4) 62(1.905,4) 63(5.715,-4) 64(5.715,4) 65(6.35,-4) 66(6.35,4) 67(6.985,-4) 68(6.985,4) 69(7.62,-4) 70(7.62,4) 71(8.255,-4) 72(8.255,4) 73(8.89,-4) 74(8.89,4) 75(9.525,-4) 76(9.525,4) 77(10.16,-4) 78(10.16,4) 79(10.795,-4) 80(10.795,4) 81(11.43,-4) 82(11.43,4) 83(12.065,-4) 84(12.065,4) 85(12.7,-4) 86(12.7,4) 87(13.335,-4) 88(13.335,4) 89(13.97,-4) 90(13.97,4) 91(14.605,-4) 92(14.605,4) 93(15.24,-4) 94(15.24,4) 95(15.875,-4) 96(15.875,4) 97(16.51,-4) 98(16.51,4) 99(17.145,-4) 100(17.145,4)
MHC-W21-601-LF
  round 1.524 hole 1.092: (-11.5,-3.05)
  round 2.108 hole 1.6: (9.5,-3.05)
  rect 0.6x2 smd: 1(6.875,0) 2(4.375,0) 3(1.875,0) 4(-0.625,0) 5(-3.125,0) 6(-5.625,0) 7(-8.05,0) 8(-9.75,0) 9(9.375,0)
  rect 1x1.5 smd: 10(5.65,-17) 11(3.15,-17) 12(-4.35,-17) 13(-6.85,-17)
  rect 0.7x2 smd: 14(-12.25,0) 15(-11.05,0)
  rect 0.5x2 smd: 16(-7.27,0) 17(-6.475,0) 18(-4.775,0) 19(-1.475,0) 20(0.225,0) 21(1.025,0) 22(2.725,0) 23(3.525,0) 24(-8.9,0) 25(-3.975,0) 26(-2.275,0)
  rect 1.3x2.4 smd: 27(-14.15,-17.05) 28(14.15,-17.05)
MS920SE-FL27E
  rect 2.286x0.762 smd: 1(0,1) 2(0,-1)
NORCOMP_DB9M_TH
  rect 1.6x1.6 hole 1.092: 1(0.051,0)
  round 1.6 hole 1.092: 2(-2.718,0) 3(-5.486,0) 4(-8.255,0) 5(-11.024,0) 6(-1.346,2.845) 7(-4.102,2.845) 8(-6.871,2.845) 9(-9.639,2.845)
  round 5.08 hole 3.048: 10(-17.983,1.422) 11(7.01,1.422)
PW_24PIN_TSSOP
  rect 0.356x1.524 smd: 1(-3.575,-2.96) 2(-2.925,-2.96) 3(-2.275,-2.96) 4(-1.625,-2.96) 5(-0.975,-2.96) 6(-0.325,-2.96) 7(0.325,-2.96) 8(0.975,-2.96) 9(1.625,-2.96) 10(2.275,-2.96) 11(2.925,-2.96) 12(3.575,-2.96) 13(3.575,2.96) 14(2.925,2.96) 15(2.275,2.96) 16(1.625,2.96) 17(0.975,2.96) 18(0.325,2.96) 19(-0.325,2.96) 20(-0.975,2.96) 21(-1.625,2.96) 22(-2.275,2.96) 23(-2.925,2.96) 24(-3.575,2.96)
QFN48
  rect 0.8x0.2 smd: 1(-3.075,2.2) 2(-3.075,1.8) 3(-3.075,1.4) 4(-3.075,1) 5(-3.075,0.6) 6(-3.075,0.2) 7(-3.075,-0.2) 8(-3.075,-0.6) 9(-3.075,-1) 10(-3.075,-1.4) 11(-3.075,-1.8) 12(-3.075,-2.2) 25(3.075,-2.2) 26(3.075,-1.8) 27(3.075,-1.4) 28(3.075,-1) 29(3.075,-0.6) 30(3.075,-0.2) 31(3.075,0.2) 32(3.075,0.6) 33(3.075,1) 34(3.075,1.4) 35(3.075,1.8) 36(3.075,2.2)
  rect 0.2x0.8 smd: 13(-2.2,-3.075) 14(-1.8,-3.075) 15(-1.4,-3.075) 16(-1,-3.075) 17(-0.6,-3.075) 18(-0.2,-3.075) 19(0.2,-3.075) 20(0.6,-3.075) 21(1,-3.075) 22(1.4,-3.075) 23(1.8,-3.075) 24(2.2,-3.075) 37(2.2,3.075) 38(1.8,3.075) 39(1.4,3.075) 40(1,3.075) 41(0.6,3.075) 42(0.2,3.075) 43(-0.2,3.075) 44(-0.6,3.075) 45(-1,3.075) 46(-1.4,3.075) 47(-1.8,3.075) 48(-2.2,3.075)
  rect 3.8x3.8 smd: 49(0,0)
QFN_72
  oval 0.95x0.3 smd: 1(-4.95,4.25) 2(-4.95,3.75) 3(-4.95,3.25) 4(-4.95,2.75) 5(-4.95,2.25) 6(-4.95,1.75) 7(-4.95,1.25) 8(-4.95,0.75) 9(-4.95,0.25) 10(-4.95,-0.25) 11(-4.95,-0.75) 12(-4.95,-1.25) 13(-4.95,-1.75) 14(-4.95,-2.25) 15(-4.95,-2.75) 16(-4.95,-3.25) 17(-4.95,-3.75) 18(-4.95,-4.25) 37(4.95,-4.25) 38(4.95,-3.75) 39(4.95,-3.25) 40(4.95,-2.75) 41(4.95,-2.25) 42(4.95,-1.75) 43(4.95,-1.25) 44(4.95,-0.75) 45(4.95,-0.25) 46(4.95,0.25) 47(4.95,0.75) 48(4.95,1.25) 49(4.95,1.75) 50(4.95,2.25) 51(4.95,2.75) 52(4.95,3.25) 53(4.95,3.75) 54(4.95,4.25)
  oval 0.3x0.95 smd: 19(-4.25,-4.95) 20(-3.75,-4.95) 21(-3.25,-4.95) 22(-2.75,-4.95) 23(-2.25,-4.95) 24(-1.75,-4.95) 25(-1.25,-4.95) 26(-0.75,-4.95) 27(-0.25,-4.95) 28(0.25,-4.95) 29(0.75,-4.95) 30(1.25,-4.95) 31(1.75,-4.95) 32(2.25,-4.95) 33(2.75,-4.95) 34(3.25,-4.95) 35(3.75,-4.95) 36(4.25,-4.95) 55(4.25,4.95) 56(3.75,4.95) 57(3.25,4.95) 58(2.75,4.95) 59(2.25,4.95) 60(1.75,4.95) 61(1.25,4.95) 62(0.75,4.95) 63(0.25,4.95) 64(-0.25,4.95) 65(-0.75,4.95) 66(-1.25,4.95) 67(-1.75,4.95) 68(-2.25,4.95) 69(-2.75,4.95) 70(-3.25,4.95) 71(-3.75,4.95) 72(-4.25,4.95)
  rect 4.85x4.85 smd: EPAD(0,0)
RAPC712
  round 4.064 hole 3.556: 1(0,0)
  round 3.683 hole 3.048: 2(-2.997,-4.801) 3(-6.248,0)
SKT-TSOP48SM
  rect 1.524x0.305 smd: 1(-9.716,5.753) 2(-9.716,5.253) 3(-9.716,4.752) 4(-9.716,4.252) 5(-9.716,3.754) 6(-9.716,3.254) 7(-9.716,2.753) 8(-9.716,2.253) 9(-9.716,1.753) 10(-9.716,1.252) 11(-9.716,0.754) 12(-9.716,0.254) 13(-9.716,-0.246) 14(-9.716,-0.747) 15(-9.716,-1.247) 16(-9.716,-1.748) 17(-9.716,-2.248) 18(-9.716,-2.746) 19(-9.716,-3.246) 20(-9.716,-3.747) 21(-9.716,-4.247) 22(-9.716,-4.747) 23(-9.716,-5.248) 24(-9.716,-5.748) 25(9.716,-5.753) 26(9.716,-5.253) 27(9.716,-4.752) 28(9.716,-4.252) 29(9.716,-3.754) 30(9.716,-3.254) 31(9.716,-2.753) 32(9.716,-2.253) 33(9.716,-1.753) 34(9.716,-1.252) 35(9.716,-0.754) 36(9.716,-0.254) 37(9.716,0.246) 38(9.716,0.747) 39(9.716,1.247) 40(9.716,1.748) 41(9.716,2.248) 42(9.716,2.746) 43(9.716,3.246) 44(9.716,3.747) 45(9.716,4.247) 46(9.716,4.747) 47(9.716,5.248) 48(9.716,5.748)
SM-7351-CAP-0402
  round 0.635 smd: 1(-0.508,0) 2(0.508,0)
SM-7351-CAP-0603
  rect 1.092x1.041 smd: 1(-0.85,0) 2(0.85,0)
SM-7351-CAP-0805
  rect 1.346x1.524 smd: 1(-1,0) 2(1,0)
SM-7351-CAP-2917
  rect 2.413x2.54 smd: 1(3.175,0) 2(-3.175,0)
SM-7351-CAP-SMDCAN
  rect 4.15x1.65 smd: 1(3.05,0) 2(-3.05,0)
SM-7351-IND-0805
  rect 1.397x1.549 smd: 1(-0.95,0) 2(0.95,0)
SM-7351-RES-0402
  round 0.635 smd: 1(-0.508,0) 2(0.508,0)
SM-7351-RES-0603
  rect 1.143x1.092 smd: 1(-0.9,0) 2(0.9,0)
SM-7351-RES-0805
  rect 1.143x1.549 smd: 1(-1.1,0) 2(1.1,0)
SM_CRY_SCC18
  rect 1.4x2.2 smd: 1(-1.25,3.2) 2(-1.25,-3.2) 3(1.25,-3.2) 4(1.25,3.2)
SM_LED_0805
  rect 1.15x1.194 smd: 1(1.125,0) 2(-1.125,0)
SM_OSC_ABM3
  rect 1.9x2.4 smd: 1(-2.05,0) 2(2.05,0)
SM_RES_0805_KELV
  rect 1.4x1.65 smd: 1(-1.3,0) 2(1.3,0)
  rect 0.127x0.127 smd: 3(-0.377,-1.186) 4(0.377,-1.186)
SM_RES_LVK12
  rect 1.75x1.1 smd: 1(-1.375,0.7) 2(1.375,0.7) 3(-1.375,-0.7) 4(1.375,-0.7)
SMCJ15CA
  rect 2.4x3.3 smd: 1(-3.3,0) 2(3.3,0)
SMD_HDMIA_RA
  rect 0.3x1.9 smd: 1(4.75,0) 2(4.25,0) 3(3.75,0) 4(3.25,0) 5(2.75,0) 6(2.25,0) 7(1.75,0) 8(1.25,0) 9(0.75,0) 10(0.25,0) 11(-0.25,0) 12(-0.75,0) 13(-1.25,0) 14(-1.75,0) 15(-2.25,0) 16(-2.75,0) 17(-3.25,0) 18(-3.75,0) 19(-4.25,0)
  round 1.778 hole 1.27: MTG1(-7.25,-1) MTG2(7.25,-1) MTG3(-7.85,-5.9) MTG4(7.85,-5.9)
SMD_SLF7055T
  rect 1.5x2.2 smd: 1(-3.15,0) 2(3.15,0)
SMDFUSEBLK
  rect 4.242x3.81 smd: 1(-3.175,0) 2(3.175,0)
SMDMSOP_10
  rect 0.254x1.016 smd: 1(-1,-2.5) 2(-0.5,-2.5) 3(0,-2.5) 4(0.5,-2.5) 5(1,-2.5) 6(1,2.5) 7(0.5,2.5) 8(0,2.5) 9(-0.5,2.5) 10(-1,2.5)
SMDSC70-5
  rect 0.406x1.016 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
SMDSC70-6
  rect 0.406x1.016 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SOD-123
  rect 0.914x1.219 smd: 1(1.651,0) 2(-1.651,0)
SOIC_8
  rect 0.61x2.184 smd: 1(-1.905,-2.603)
  oval 0.61x2.184 smd: 2(-0.635,-2.603) 3(0.635,-2.603) 4(1.905,-2.603) 5(1.905,2.603) 6(0.635,2.603) 7(-0.635,2.603) 8(-1.905,2.603)
SOT23-3
  rect 0.787x0.889 smd: D(0,1.003) G(-0.94,-1.003) S(0.94,-1.003)
SOT223_6PIN
  rect 0.991x1.499 smd: 1(-2.54,-3.15) 2(-1.27,-3.15) 3(0,-3.15) 4(1.27,-3.15) 5(2.54,-3.15)
  rect 3.277x1.499 smd: 6(0,3.15)
SW_B3SL-1022P
  rect 2.75x1 smd: 1(2.875,-2) 2(-2.875,-2) 3(2.875,2) 4(-2.875,2)
TH_SW_T551101
  round 1.524 hole 1.092: 1(0,0) 2(0,-2.54) 3(0,-5.08) M1(-5.08,0) M2(-5.08,-5.08)
TH_TP_5002
  round 1.778 hole 1.016: 1(0,0)
TP_SMD1MMCIRCLE
  round 1.016 smd: 1(0,0)
U_5_DCK
  rect 0.432x1.27 smd: 1(0.65,0.775) 2(0,0.775) 3(-0.65,0.775) 4(-0.65,-0.884) 5(0.65,-0.884)
U_5_DRL
  rect 0.3x0.45 smd: 1(-0.5,-0.675) 2(0,-0.675) 3(0.5,-0.675) 4(0.5,0.675) 5(-0.5,0.675)
U_6_DCK
  rect 0.432x1.27 smd: 1(0.65,0.775) 2(0,0.775) 3(-0.65,0.775) 4(-0.65,-0.884) 5(0.65,-0.884)
U_6_DRY
  rect 0.305x0.508 smd: 1(-0.5,-0.439) 2(0,-0.439) 3(0.5,-0.439) 4(0.5,0.439) 5(0,0.439) 6(-0.5,0.439)
U_8_D
  rect 0.6x2 smd: 1(-1.905,-2.4) 2(-0.635,-2.4) 3(0.635,-2.4) 4(1.905,-2.4) 5(1.905,2.4) 6(0.635,2.4) 7(-0.635,2.4) 8(-1.905,2.4)
U_8_DCU
  rect 0.254x1.27 smd: 1(-0.749,-1.473) 2(-0.249,-1.473) 3(0.249,-1.473) 4(0.749,-1.473) 5(0.749,1.473) 6(0.249,1.473) 7(-0.249,1.473) 8(-0.749,1.473)
U_10_RSE
  rect 0.3x0.58 smd: 1(-0.75,-0.635) 2(-0.25,-0.635) 3(0.25,-0.635) 4(0.75,-0.635) 6(0.75,0.635) 7(0.25,0.635) 8(-0.25,0.635) 9(-0.75,0.635)
  rect 0.63x0.35 smd: 5(0.86,0) 10(-0.86,0)
U_16_D
  rect 0.6x2 smd: 1(-4.445,-2.4) 2(-3.175,-2.4) 3(-1.905,-2.4) 4(-0.635,-2.4) 5(0.635,-2.4) 6(1.905,-2.4) 7(3.175,-2.4) 8(4.445,-2.4) 9(4.445,2.4) 10(3.175,2.4) 11(1.905,2.4) 12(0.635,2.4) 13(-0.635,2.4) 14(-1.905,2.4) 15(-3.175,2.4) 16(-4.445,2.4)
U_16_PW
  rect 0.35x1.6 smd: 1(-2.275,-2.8) 2(-1.625,-2.8) 3(-0.975,-2.8) 4(-0.325,-2.8) 5(0.325,-2.8) 6(0.975,-2.8) 7(1.625,-2.8) 8(2.275,-2.8) 9(2.275,2.8) 10(1.625,2.8) 11(0.975,2.8) 12(0.325,2.8) 13(-0.325,2.8) 14(-0.975,2.8) 15(-1.625,2.8) 16(-2.275,2.8)
U_20_DSBGA
  round 0.254 smd: A1(0.6,-0.8) A2(0.2,-0.8) A3(-0.2,-0.8) A4(-0.6,-0.8) B1(0.6,-0.4) B2(0.2,-0.4) B3(-0.2,-0.4) B4(-0.6,-0.4) C1(0.6,0) C2(0.2,0) C3(-0.2,0) C4(-0.6,0) D1(0.6,0.4) D2(0.2,0.4) D3(-0.2,0.4) D4(-0.6,0.4) E1(0.6,0.8) E2(0.2,0.8) E3(-0.2,0.8) E4(-0.6,0.8)
U_24_RTW
  rect 0.85x0.28 smd: 1(-1.975,1.25) 2(-1.975,0.75) 3(-1.975,0.25) 4(-1.975,-0.25) 5(-1.975,-0.75) 6(-1.975,-1.25) 13(1.975,-1.25) 14(1.975,-0.75) 15(1.975,-0.25) 16(1.975,0.25) 17(1.975,0.75) 18(1.975,1.25)
  rect 0.28x0.85 smd: 7(-1.25,-1.975) 8(-0.75,-1.975) 9(-0.25,-1.975) 10(0.25,-1.975) 11(0.75,-1.975) 12(1.25,-1.975) 19(1.25,1.975) 20(0.75,1.975) 21(0.25,1.975) 22(-0.25,1.975) 23(-0.75,1.975) 24(-1.25,1.975)
  rect 2.45x2.45 smd: TPAD(0,0)
U_48_RSL
  rect 0.85x0.2 smd: 1(-2.975,2.2) 2(-2.975,1.8) 3(-2.975,1.4) 4(-2.975,1) 5(-2.975,0.6) 6(-2.975,0.2) 7(-2.975,-0.2) 8(-2.975,-0.6) 9(-2.975,-1) 10(-2.975,-1.4) 11(-2.975,-1.8) 12(-2.975,-2.2) 25(2.975,-2.2) 26(2.975,-1.8) 27(2.975,-1.4) 28(2.975,-1) 29(2.975,-0.6) 30(2.975,-0.2) 31(2.975,0.2) 32(2.975,0.6) 33(2.975,1) 34(2.975,1.4) 35(2.975,1.8) 36(2.975,2.2)
  rect 0.2x0.85 smd: 13(-2.2,-2.975) 14(-1.8,-2.975) 15(-1.4,-2.975) 16(-1,-2.975) 17(-0.6,-2.975) 18(-0.2,-2.975) 19(0.2,-2.975) 20(0.6,-2.975) 21(1,-2.975) 22(1.4,-2.975) 23(1.8,-2.975) 24(2.2,-2.975) 37(2.2,2.975) 38(1.8,2.975) 39(1.4,2.975) 40(1,2.975) 41(0.6,2.975) 42(0.2,2.975) 43(-0.2,2.975) 44(-0.6,2.975) 45(-1,2.975) 46(-1.4,2.975) 47(-1.8,2.975) 48(-2.2,2.975)
  rect 4.05x4.05 smd: PPAD(-0.225,0.225)
unnamed
  round 1.27 hole 2.794 unplated: (0,0)
USB_STD_A_TH
  round 1.676 hole 0.914: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0)
  round 2.794 hole 2.311: S1(-3.073,-2.718) S2(10.058,-2.718)
VLCF5020T
  custom 0.525x0.525 smd: 1(-1.7,0) 2(1.7,0)
ZX62-AB-5PA
  rect 1.9x1.9 smd: (-1.2,-2.675) (1.2,-2.675)
  rect 0.4x1.35 smd: 1(-1.3,0) 2(-0.65,0) 3(0,0) 4(0.65,0) 5(1.3,0)
  rect 2.1x1.6 smd: S1(-3.1,-0.125) S2(3.1,-0.125)
  rect 1.8x1.9 smd: S3(-4.1,-2.675) S4(4.1,-2.675)

## Nets
DGND: BT1.2(NEG) C1.2 C6.2 C7.2 C8.2 C15.2 C16.2 C17.2 C19.2 C23.2 C24.2 C25.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C34.2 C35.2 C36.2 C41.2 C42.2 C43.2 C45.2 C46.2 C47.2 C48.2 C50.2 C52.2 C53.2 C56.2 C60.2 C61.2 C62.2 C64.2 C65.2 C66.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C76.2 C77.2 C78.2 C79.2 C80.2 C82.2 C83.2 C84.2(NEG) C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C96.2 C97.2 C98.2 C101.2 C102.2 C103.2 C104.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C172.2 C173.2 C174.2 C175.2 C177.2 C179.2 C180.2 C181.2 C182.2(NEG) C183.2 C184.2 C185.2(NEG) C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C204.1 C205.2 C206.2 C207.2 C212.1 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.1 C272.1 C273.2 C274.2 D2.2(ANODE) D3.1(CATHODE) D9.2(ANODE) D10.2(ANODE) FB10.2 FB14.1 FB19.1 J1.2 J1.3 J2.8(GND#8) J2.10(GND#10) J2.12(GND#12) J2.16(GND#16) J2.20(GND#20) J3.27 J3.28 J4.7 J4.8 J5.1 J5.10 J5.11 J5.20 J5.30 J5.37 J6.3 J6.14 J6.20 J6.25 J7.19 J7.20 J8.19 J8.20 J9.10 J10.2(DAT2_S) J10.5(DAT1_S) J10.8(DAT0_S) J10.11(CLK_S) J10.17(DDC/CEC GND) J10.MTG1 J10.MTG2 J10.MTG3 J10.MTG4 J11.2 J11.3 J11.6 J11.9 J11.18 J11.19 J11.22 J11.35 J11.37 J11.39 J11.42 J11.47 J11.60 J11.63 J11.64 J11.77 J11.83 J11.87 J11.92 J11.95 J11.97 J12.5 J12.10 J12.11 J13.3(#3_MMC+/MMCM/RSMMC/MMC/SD) J13.6(#6_MMC+/MMCM/RSMMC/MMC/SD) J13.18(#3_MINISD) J13.21(#6_MINISD) J13.27(GND1) J13.28(GND2) J14.5(GND) J15.1 J15.D2 J15.D3 J16.15 J16.27 J16.28 J17.3 J18.4(GND) J19.5 J19.10 J19.19 J19.20 Q1.S(SOURCE) Q2.S(SOURCE) Q3.S(SOURCE) Q4.S(SOURCE) R4.1(P1) R22.1(P1) R48.1(P1) R64.2(P2) R65.1(P1) R73.1(P1) R79.1(P1) R86.1(P1) R93.1(P1) R94.1(P1) R95.1(P1) R112.1(P1) R114.1(P1) R115.1(P1) R116.1(P1) R117.1(P1) R118.1(P1) R119.1(P1) R120.1(P1) R121.1(P1) R122.1(P1) R123.1(P1) R124.1(P1) R125.1(P1) R126.1(P1) R127.1(P1) R128.1(P1) R129.1(P1) R274.1(P1) R292.1(P1) R304.1(P1) R308.1(P1) R325.1(P1) R326.1(P1) R360.1(P1) R381.1(P1) R383.2(P2) R385.1(P1) R387.2(P2) R406.1(P1) R411.1(P1) R413.1(P1) R414.1(P1) R419.1(P1) R422.1(P1) R426.1(P1) R431.1(P1) R435.1(P1) R516.1(P1) R521.1(P1) R541.1(P1) R569.1(P1) SW1.M1 SW1.M2 SW2.1 SW2.2 TP27.1 TP28.1 TP29.1 TP30.1 U1.3(GND) U2.A1(VSS#A1) U2.A18(VSS#A18) U2.F8(VSS#F8) U2.G8(VSS#G8) U2.G9(VSS#G9) U2.G11(VSS#G11) U2.G12(VSS#G12) U2.H6(VSS#H6) U2.H7(VSS#H7) U2.H8(VSS#H8) U2.H9(VSS#H9) U2.H10(VSS#H10) U2.H12(VSS#H12) U2.J6(VSS#J6) U2.J7(VSS#J7) U2.J8(VSS#J8) U2.J9(VSS#J9) U2.J10(VSS#J10) U2.J11(VSS#J11) U2.K7(VSS#K7) U2.K9(VSS#K9) U2.K10(VSS#K10) U2.K11(VSS#K11) U2.L10(VSS#L10) U2.L11(VSS#L11) U2.L12(VSS#L12) U2.L13(VSS#L13) U2.M6(VSS#M6) U2.M7(VSS#M7) U2.M8(VSS#M8) U2.M9(VSS#M9) U2.M10(VSS#M10) U2.M12(VSS#M12) U2.M14(VSSA_USB#M14) U2.N7(VSS#N7) U2.N10(VSS#N10) U2.N11(VSS#N11) U2.N14(VSSA_USB#N14) U2.V1(VSS#V1) U2.V18(VSS#V18) U3.3(GND) U4.15(GNDIO) U4.17(REFGND) U4.34(GND1) U4.43(GND2) U4.PPAD(GNDP) U5.2(GND) U6.4(GND) U6.5(2A) U6.6(2B) U7.1(A0) U7.2(A1) U7.3(A2) U7.4(VSS) U8.A3(VSS#A3) U8.A7(VSSQ#A7) U8.B2(VSSQ#B2) U8.B8(VSSQ#B8) U8.D2(VSSQ#D2) U8.D8(VSSQ#D8) U8.E3(VSS#E3) U8.E7(VSSDL) U8.J1(VSS#J1) U8.K9(VSS#K9) U9.13(GND#13) U9.25(GND#25) U9.36(GND#36) U9.48(GND#48) U10.43(CGND) U10.55(RSVDL) U10.57(IOGND) U10.63(AGND) U10.70(VDDQ) U10.EPAD U11.6(GND#6) U11.14(GND#14) U11.19(GND#19) U12.2(GND) U13.2(1DIR) U13.8(GND#8) U13.9(GND#9) U13.14(2O\E\) U13.15(1O\E\) U14.3(2DIR) U14.8(GND#8) U14.9(GND#9) U14.14(2O\E\) U14.15(1O\E\) U15.8(GND#8) U15.9(GND#9) U15.14(2O\E\) U15.15(1O\E\) U16.3(2DIR) U16.8(GND#8) U16.9(GND#9) U16.14(2O\E\) U16.15(1O\E\) U17.3(GND#3) U17.6(GND#6) U18.15(GND) U19.5(GND) U20.5(GND) U21.4(GND) U22.1(GND) U23.4(GND) U24.B4(SYNC) U24.C1(PGND#C1) U24.C2(PGND#C2) U24.C3(GND#C3) U24.D3(GND#D3) U24.E4(GND#E4) U25.49(EP) U26.3(GND) U27.1(A1) U27.2(A0) U27.7(GND) U28.2(GND#2) U28.11(GND#11) U28.TPAD U29.1(GND) U30.4(GND) U31.A3(VSS#A3) U31.A7(VSSQ#A7) U31.B2(VSSQ#B2) U31.B8(VSSQ#B8) U31.D2(VSSQ#D2) U31.D8(VSSQ#D8) U31.E3(VSS#E3) U31.E7(VSSDL) U31.J1(VSS#J1) U31.K9(VSS#K9) U32.1(A1) U32.7(GND) U33.2(GND) U33.5(DIR)
GND_ETH: C271.2 C272.2 J15.SHLD1 J15.SHLD2
GND_OSC0: C4.2 C5.2 C67.2 U2.V11(VSS_OSC)
GND_OSC1: C2.1 C3.1 U2.A5(VSS_RTC)
GNDA_ADC: C63.2 FB10.1 R45.1(P1) R461.1(P1) U2.E8(VSSA_ADC)
GNDA_TSC: C11.2 C12.2 C13.2 C14.2 J9.11 J9.12 R45.2(P2) R51.2(P2)
GNDUSB0: FB14.2 J14.S1 J14.S2 J14.S3 J14.S4
GNDUSB1: FB19.2 J18.S1 J18.S2
V1_2D: C159.1 C242.1 C268.1 FB11.2 FB13.2 U12.5(OUT)
V1_2D_EN: R478.1(P1) U12.3(EN)
V1_8D: C87.1 C133.1 C138.1 C162.1 C164.1 C166.1 C168.1 C170.1 C261.1 J3.1 J8.2 J11.8 J11.62 R329.2(P2) R330.2(P2) R331.2(P2) R332.2(P2) R333.2(P2) R334.2(P2) R472.1(P1) R519.2(P2) U13.16(VCCB) U14.16(VCCB) U15.16(VCCB) U16.16(VCCB) U28.17(VCCB1)
V3_3D: C134.1 C135.1 C140.1 C175.1 C190.1 C191.1 C215.1 C222.1 C245.1 FB15.1 FB17.1 J5.39 J6.15 J9.2 R68.1(P1) R386.2(P2) R453.2(P2) R454.2(P2) R455.2(P2) R544.2(P2) U18.16(VCC) U25.4(VDD33) U27.6(VS) U32.6(VS)
V3_3ETHJCK: FB17.2 J15.2
V5_0D: C132.1 C136.1 C137.1 C157.1 C184.1 C269.1 C270.1 J3.2 J7.1 J7.2 R275.2(P2) R276.2(P2) R520.2(P2) U11.11(VCC5V) U22.2(IN#2) U22.3(IN#3) U24.E1(VOUT#E1) U24.E2(VOUT#E2) U29.2(IN#2) U29.3(IN#3)
V5_0D_EN: R386.1(P1) U24.A4(EN)
V5_0HDMICONN: C158.1 J10.18(+5V) U11.13(5V_OUT)
VBAT: C84.1(POS) C85.1 C86.1 C88.1 C112.1 C139.1 C141.1 C160.1 C173.1 C187.1 C214.1 C234.1 C236.1 C238.1 C240.1 C250.1 C251.1 C252.1 C253.1 C254.1 C263.1 J6.19 J8.1 J16.5 J19.1 J19.2 R50.2(P2) R80.2(P2) R81.2(P2) R82.2(P2) R83.2(P2) R239.2(P2) SW1.2 TP25.1 U4.3(VCC3) U4.6(VCC6) U4.13(VCCIO) U4.23(VCC5) U4.28(VCC7) U4.36(VCC1) U4.41(VCC2) U4.47(VCC4) U5.1(IN) U5.3(EN) U12.1(IN) U17.2(IN) U24.A1(VIN#A1) U24.A2(VIN#A2)
VBUS0_OTG_CAP: C182.1(POS) J36.2
VBUS1_OTG_CAP: C185.1(POS) J37.2 R558.2(P2)
VDD1_SMPS: J19.6 R46.1(I1) R469.1(P1) U32.8(VBUS)
VDD2_SMPS: J19.7 R32.1(I1) R468.1(P1) U27.8(VBUS)
VDD3_SMPS: C235.1 J19.8 R470.1(P1)
VDD_CORE: C16.1 C17.1 C19.1 C23.1 C24.1 C34.1 C35.1 C36.1 C232.1 R32.2(I2) U2.F6(VDD_CORE#F6) U2.F7(VDD_CORE#F7) U2.G6(VDD_CORE#G6) U2.G7(VDD_CORE#G7) U2.G10(VDD_CORE#G10) U2.H11(VDD_CORE#H11) U2.J12(VDD_CORE#J12) U2.K6(VDD_CORE#K6) U2.K8(VDD_CORE#K8) U2.K12(VDD_CORE#K12) U2.L6(VDD_CORE#L6) U2.L7(VDD_CORE#L7) U2.L8(VDD_CORE#L8) U2.L9(VDD_CORE#L9) U2.M11(VDD_CORE#M11) U2.M13(VDD_CORE#M13) U2.N8(VDD_CORE#N8) U2.N9(VDD_CORE#N9) U2.N12(VDD_CORE#N12) U2.N13(VDD_CORE#N13)
VDD_MPU: C41.1 C52.1 C53.1 C56.1 C83.1 C246.1 R46.2(I2) U2.F10(VDD_MPU#F10) U2.F11(VDD_MPU#F11) U2.F12(VDD_MPU#F12) U2.F13(VDD_MPU#F13) U2.G13(VDD_MPU#G13) U2.H13(VDD_MPU#H13) U2.J13(VDD_MPU#J13)
VDD_RTC: C65.1 U2.D6(CAP_VDD_RTC)
VDDA1P8V_USB0: C61.1 R502.2(I2) U2.N16(VDDA1P8V_USB0) U2.R16(VDDA1P8V_USB1)
VDDA3P3V_USB0: C62.1 R504.2(I2) U2.N15(VDDA3P3V_USB0) U2.R15(VDDA3P3V_USB1)
VDDA_ADC: FB9.1 Q5.S(SOURCE) R30.1(P1) R462.1(P1) R501.2(I2) R565.2(P2)
VDDH_PHY: C192.1 R389.1(P1) R391.2(P2) U25.10(VDDH_REG)
VDDL_PHY: C196.1 C197.1 C256.1 FB16.2 L7.1 R394.1(P1) U25.47(DVDDL)
VDDMPU_MON: R561.1(P1) U2.A2(VDD_MPU_MON)
VDDS_DDR: C125.1 C126.1 C155.1 C156.1 C174.1 C181.1 C188.1 C189.1 C195.1 C202.1 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C266.1 C267.1 J19.9 R467.1(P1) R508.1(I1) R542.1(P1) U8.A1(VDD#A1) U8.A9(VDDQ#A9) U8.C1(VDDQ#C1) U8.C3(VDDQ#C3) U8.C7(VDDQ#C7) U8.C9(VDDQ#C9) U8.E1(VDDL) U8.E9(VDD#E9) U8.H9(VDD#H9) U8.L1(VDD#L1) U31.A1(VDD#A1) U31.A9(VDDQ#A9) U31.C1(VDDQ#C1) U31.C3(VDDQ#C3) U31.C7(VDDQ#C7) U31.C9(VDDQ#C9) U31.E1(VDDL) U31.E9(VDD#E9) U31.H9(VDD#H9) U31.L1(VDD#L1)
VDDS_OSC: C67.1 R506.1(I1) U2.R11(VDDS_OSC)
VDDS_PLL_CORE_LCD: C64.1 R503.1(I1) U2.R10(VDDS_PLL_CORE_LCD)
VDDS_PLL_DDR: C73.1 R507.2(I2) U2.E7(VDDS_PLL_DDR)
VDDS_PLL_MPU: C70.1 R497.2(I2) U2.H15(VDDS_PLL_MPU)
VDDS_RTC: C66.1 R505.1(I1) U2.D7(VDDS_RTC)
VDDS_SRAM_CORE_BG: C68.1 R500.2(I2) U2.E9(VDDS_SRAM_CORE_BG)
VDDS_SRAM_MPU_BB: C69.1 R499.2(I2) U2.D10(VDDS_SRAM_MPU_BB)
VDDSHV1: C127.1 C128.1 C129.1 C130.1 C131.1 C167.1 C169.1 FB1.1 FB2.1 R130.2(P2) R131.2(P2) R132.2(P2) R493.2(I2) R518.2(P2) U9.12(VCC#12) U9.34(VCC#34) U9.37(VCC#37) U9.39(VCC#39) U15.1(VCCA) U15.2(1DIR) U15.3(2DIR)
VDDSHV2: C15.1 C74.1 C148.1 FB5.1 J6.11 R515.2(P2) R545.2(I2) U28.5(VCCA) U28.21(VCCB0)
VDDSHV3: FB20.1 FB21.1 R546.2(I2)
VDDSHV4: C180.1 C255.1 FB4.1 J13.4(#4_MMC+/MMCM/RSMMC/MMC/SD) J13.19(#4_MINISD) R365.2(P2) R366.2(P2) R367.2(P2) R368.2(P2) R369.2(P2) R370.2(P2) R371.2(P2) R372.2(P2) R373.2(P2) R494.2(I2) U19.10(VCC) U20.10(VCC)
VDDSHV5: FB3.1 FB6.1 R388.2(P2) R409.2(P2) R495.2(I2)
VDDSHV6: C6.1 C8.1 C115.1 C116.1 C149.1 C163.1 C165.1 C213.1 C243.1 D8.2(ANODE) FB7.1 FB8.1 FB12.2 J2.5(TVDD) R6.2(P2) R70.2(P2) R71.2(P2) R72.2(P2) R96.2(P2) R97.2(P2) R98.2(P2) R99.2(P2) R100.2(P2) R101.2(P2) R102.2(P2) R103.2(P2) R104.2(P2) R105.2(P2) R106.2(P2) R107.2(P2) R108.2(P2) R109.2(P2) R110.2(P2) R111.2(P2) R306.2(P2) R378.2(P2) R382.1(P1) R412.1(P1) R496.2(I2) R547.2(P2) R548.2(P2) R552.2(P2) R553.2(P2) R554.2(P2) R555.2(P2) R559.2(P2) R567.2(P2) R568.2(P2) R570.2(P2) U3.5(VCC) U7.8(VCC) U11.24(VCCA) U13.1(VCCA) U13.3(2DIR) U14.1(VCCA) U14.2(1DIR) U16.1(VCCA) U16.2(1DIR) U21.1(VCC) U26.5(VCC) U33.1(VCCA)
AM335X_AIN0: J9.14 R461.2(P2) U2.B6(AIN0)
AM335X_AIN1: J9.16 R462.2(P2) U2.C7(AIN1)
AM335X_AIN2: J9.18 U2.B7(AIN2)
AM335X_AIN3: J9.20 U2.A7(AIN3)
AM335X_AIN4: J9.13 U2.C8(AIN4)
AM335X_AIN5: J9.15 U2.B8(AIN5)
AM335X_AIN6: J9.17 U2.A8(AIN6)
AM335X_AIN7: J9.19 R23.1(P1) R571.2(P2) U2.C9(AIN7)
AM335X_DDR_A0: R18.1(P1) U2.F3(DDR_A0)
AM335X_DDR_A1: R21.1(P1) U2.H1(DDR_A1)
AM335X_DDR_A2: R31.1(P1) U2.E4(DDR_A2)
AM335X_DDR_A3: R33.1(P1) U2.C3(DDR_A3)
AM335X_DDR_A4: R34.1(P1) U2.C2(DDR_A4)
AM335X_DDR_A5: R35.1(P1) U2.B1(DDR_A5)
AM335X_DDR_A6: R36.1(P1) U2.D5(DDR_A6)
AM335X_DDR_A7: R37.1(P1) U2.E2(DDR_A7)
AM335X_DDR_A8: R38.1(P1) U2.D4(DDR_A8)
AM335X_DDR_A9: R39.1(P1) U2.C1(DDR_A9)
AM335X_DDR_A10: R40.1(P1) U2.F4(DDR_A10)
AM335X_DDR_A11: R41.1(P1) U2.F2(DDR_A11)
AM335X_DDR_A12: R42.1(P1) U2.E3(DDR_A12)
AM335X_DDR_A13: R43.1(P1) U2.H3(DDR_A13)
AM335X_DDR_A14: R44.1(P1) U2.H4(DDR_A14)
AM335X_DDR_BA0: R47.1(P1) U2.C4(DDR_BA0)
AM335X_DDR_BA1: R49.1(P1) U2.E1(DDR_BA1)
AM335X_DDR_BA2: R549.1(P1) U2.B3(DDR_BA2)
AM335X_DDR_CASN: R13.1(P1) U2.F1(DDR_CASN)
AM335X_DDR_CKE: R537.1(P1) U2.G3(DDR_CKE)
AM335X_DDR_CLK: R11.1(P1) U2.D2(DDR_CK)
AM335X_DDR_CLKN: R12.1(P1) U2.D1(DDR_CKN)
AM335X_DDR_CSN: R538.1(P1) U2.H2(DDR_CSN0)
AM335X_DDR_D0: R429.1(P1) U2.M3(DDR_D0)
AM335X_DDR_D1: R522.1(P1) U2.M4(DDR_D1)
AM335X_DDR_D2: R523.1(P1) U2.N1(DDR_D2)
AM335X_DDR_D3: R524.1(P1) U2.N2(DDR_D3)
AM335X_DDR_D4: R525.1(P1) U2.N3(DDR_D4)
AM335X_DDR_D5: R526.1(P1) U2.N4(DDR_D5)
AM335X_DDR_D6: R527.1(P1) U2.P3(DDR_D6)
AM335X_DDR_D7: R528.1(P1) U2.P4(DDR_D7)
AM335X_DDR_D8: R529.1(P1) U2.J1(DDR_D8)
AM335X_DDR_D9: R530.1(P1) U2.K1(DDR_D9)
AM335X_DDR_D10: R531.1(P1) U2.K2(DDR_D10)
AM335X_DDR_D11: R532.1(P1) U2.K3(DDR_D11)
AM335X_DDR_D12: R533.1(P1) U2.K4(DDR_D12)
AM335X_DDR_D13: R534.1(P1) U2.L3(DDR_D13)
AM335X_DDR_D14: R535.1(P1) U2.L4(DDR_D14)
AM335X_DDR_D15: R536.1(P1) U2.M1(DDR_D15)
AM335X_DDR_DQM0: R16.1(P1) U2.M2(DDR_DQM0)
AM335X_DDR_DQM1: R19.1(P1) U2.J2(DDR_DQM1)
AM335X_DDR_DQS0: R17.1(P1) U2.P1(DDR_DQS0)
AM335X_DDR_DQS1: R20.1(P1) U2.L1(DDR_DQS1)
AM335X_DDR_DQSN0: R539.1(P1) U2.P2(DDR_DQSN0)
AM335X_DDR_DQSN1: R540.1(P1) U2.L2(DDR_DQSN1)
AM335X_DDR_RASN: R14.1(P1) U2.G4(DDR_RASN)
AM335X_DDR_WEN: R15.1(P1) U2.B2(DDR_WEN)
AM335X_DDRODT: R543.1(P1) U2.G1(DDR_ODT)
AM335X_ECAP0_IN_PWM0_OUT: R210.1(P1) R255.2(P2) U2.C18(ECAP0_IN_PWM0_OUT)
AM335X_EXT_WAKEUP: R207.2(P2) R405.2(P2) U2.C5(EXT_WAKEUP)
AM335X_EXTINTN: R113.1(P1) R324.2(P2) R479.2(P2) U2.B18(NMIN)
AM335X_GMII1_COL: R66.2(P2) R231.2(P2) R320.2(P2) R404.2(P2) U2.H16(MII1_COL)
AM335X_GMII1_CRS: R235.2(P2) R316.2(P2) U2.H17(MII1_CRS)
AM335X_GMII1_MDIO_CLK: R433.2(P2) U2.M18(MDIO_CLK)
AM335X_GMII1_MDIO_DATA: R434.2(P2) U2.M17(MDIO_DATA)
AM335X_GMII1_REFCLK: R188.1(P1) R321.2(P2) R410.1(P1) R432.2(P2) U2.H18(MII1_REFCLK)
AM335X_GMII1_RXCLK: R423.2(P2) U2.L18(MII1_RXCLK)
AM335X_GMII1_RXD0: R424.2(P2) U2.M16(MII1_RXD0)
AM335X_GMII1_RXD1: R425.2(P2) U2.L15(MII1_RXD1)
AM335X_GMII1_RXD2: R427.2(P2) U2.L16(MII1_RXD2)
AM335X_GMII1_RXD3: R428.2(P2) U2.L17(MII1_RXD3)
AM335X_GMII1_RXDV: R430.2(P2) U2.J17(MII1_RXDV)
AM335X_GMII1_RXERR: R237.2(P2) R317.2(P2) U2.J15(MII1_RXERR)
AM335X_GMII1_TXCLK: R415.2(P2) U2.K18(MII1_TXCLK)
AM335X_GMII1_TXD0: R416.2(P2) U2.K17(MII1_TXD0)
AM335X_GMII1_TXD1: R417.2(P2) U2.K16(MII1_TXD1)
AM335X_GMII1_TXD2: R418.2(P2) U2.K15(MII1_TXD2)
AM335X_GMII1_TXD3: R420.2(P2) U2.J18(MII1_TXD3)
AM335X_GMII1_TXEN: R421.2(P2) U2.J16(MII1_TXEN)
AM335X_GPMC_A0: R193.2(P2) R323.2(P2) R350.1(P1) R437.2(P2) U2.R13(GPMC_A0)
AM335X_GPMC_A1: R439.2(P2) R456.2(P2) U2.V14(GPMC_A1)
AM335X_GPMC_A2: R440.2(P2) R457.2(P2) U2.U14(GPMC_A2)
AM335X_GPMC_A3: R441.2(P2) R458.2(P2) U2.T14(GPMC_A3)
AM335X_GPMC_A4: R206.2(P2) R296.2(P2) R442.2(P2) U2.R14(GPMC_A4)
AM335X_GPMC_A5: R209.2(P2) R444.2(P2) R509.2(P2) U2.V15(GPMC_A5)
AM335X_GPMC_A6: R214.2(P2) R446.2(P2) U2.U15(GPMC_A6)
AM335X_GPMC_A7: R217.2(P2) R447.2(P2) R510.2(P2) U2.T15(GPMC_A7)
AM335X_GPMC_A8: R223.2(P2) R450.2(P2) R511.2(P2) U2.V16(GPMC_A8)
AM335X_GPMC_A9: R226.2(P2) R512.2(P2) U2.U16(GPMC_A9)
AM335X_GPMC_A10: R230.2(P2) R384.1(P1) U2.T16(GPMC_A10)
AM335X_GPMC_A11: R233.2(P2) U2.V17(GPMC_A11)
AM335X_GPMC_AD0: R140.2(P2) R171.1(P1) U2.U7(GPMC_AD0)
AM335X_GPMC_AD1: R141.2(P2) R169.1(P1) U2.V7(GPMC_AD1)
AM335X_GPMC_AD2: R142.2(P2) R167.1(P1) U2.R8(GPMC_AD2)
AM335X_GPMC_AD3: R143.2(P2) R165.1(P1) U2.T8(GPMC_AD3)
AM335X_GPMC_AD4: R144.2(P2) R163.1(P1) U2.U8(GPMC_AD4)
AM335X_GPMC_AD5: R145.2(P2) R161.1(P1) U2.V8(GPMC_AD5)
AM335X_GPMC_AD6: R146.2(P2) R159.1(P1) U2.R9(GPMC_AD6)
AM335X_GPMC_AD7: R147.2(P2) R157.1(P1) U2.T9(GPMC_AD7)
AM335X_GPMC_AD8: R148.2(P2) R261.2(P2) R278.2(P2) U2.U10(GPMC_AD8)
AM335X_GPMC_AD9: R149.2(P2) R263.2(P2) R286.2(P2) U2.T10(GPMC_AD9)
AM335X_GPMC_AD10: R150.2(P2) R242.2(P2) R295.2(P2) U2.T11(GPMC_AD10)
AM335X_GPMC_AD11: R151.2(P2) R243.2(P2) R279.2(P2) U2.U12(GPMC_AD11)
AM335X_GPMC_AD12: R152.2(P2) R264.2(P2) R287.2(P2) U2.T12(GPMC_AD12)
AM335X_GPMC_AD13: R153.2(P2) R247.2(P2) R297.2(P2) U2.R12(GPMC_AD13)
AM335X_GPMC_AD14: R154.2(P2) R248.2(P2) R280.2(P2) U2.V13(GPMC_AD14)
AM335X_GPMC_AD15: R155.2(P2) R253.2(P2) R298.2(P2) U2.U13(GPMC_AD15)
AM335X_GPMC_ADVN_ALE: R137.2(P2) R182.2(P2) U2.R7(GPMC_ADVN_ALE)
AM335X_GPMC_BE0N_CLE: R136.2(P2) R184.2(P2) U2.T6(GPMC_BEN0_CLE)
AM335X_GPMC_BE1N: R491.2(P2) U2.U18(GPMC_BEN1)
AM335X_GPMC_CLK: R459.2(P2) R492.1(P1) U2.V12(GPMC_CLK)
AM335X_GPMC_CS0N: R135.2(P2) R183.2(P2) U2.V6(GPMC_CSN0)
AM335X_GPMC_CS1N: R175.1(P1) U2.U9(GPMC_CSN1)
AM335X_GPMC_CS2N: R173.1(P1) U2.V9(GPMC_CSN2)
AM335X_GPMC_CS3N: R460.2(P2) U2.T13(GPMC_CSN3)
AM335X_GPMC_OEN_REN: R134.2(P2) R189.2(P2) U2.T7(GPMC_OEN_REN)
AM335X_GPMC_WAIT: R133.2(P2) R179.2(P2) U2.T17(GPMC_WAIT0)
AM335X_GPMC_WEN: R138.2(P2) R191.2(P2) U2.U6(GPMC_WEN)
AM335X_GPMC_WPN: R139.2(P2) R180.2(P2) U2.U17(GPMC_WPN)
AM335X_I2C0_SCL: R58.2(P2) R265.2(P2) R547.1(P1) R551.2(P2) U2.C16(I2C0_SCL) U7.6(SCL)
AM335X_I2C0_SDA: R59.2(P2) R268.2(P2) R548.1(P1) R550.2(P2) U2.C17(I2C0_SDA) U7.5(SDA)
AM335X_LCD_AC_BIAS_EN: R273.2(P2) R312.2(P2) U2.R6(LCD_AC_BIAS_EN)
AM335X_LCD_DATA0: R96.1(P1) R240.2(P2) R299.2(P2) SW3.16 U2.R1(LCD_DATA0)
AM335X_LCD_DATA1: R97.1(P1) R241.2(P2) R300.2(P2) SW3.15 U2.R2(LCD_DATA1)
AM335X_LCD_DATA2: R98.1(P1) R245.2(P2) R301.2(P2) SW3.14 U2.R3(LCD_DATA2)
AM335X_LCD_DATA3: R99.1(P1) R246.2(P2) R302.2(P2) SW3.13 U2.R4(LCD_DATA3)
AM335X_LCD_DATA4: R100.1(P1) R251.2(P2) R303.2(P2) SW3.12 U2.T1(LCD_DATA4)
AM335X_LCD_DATA5: R101.1(P1) R252.2(P2) R288.2(P2) SW3.11 U2.T2(LCD_DATA5)
AM335X_LCD_DATA6: R102.1(P1) R270.2(P2) R289.2(P2) SW3.10 U2.T3(LCD_DATA6)
AM335X_LCD_DATA7: R103.1(P1) R259.2(P2) R290.2(P2) SW3.9 U2.T4(LCD_DATA7)
AM335X_LCD_DATA8: R104.1(P1) R262.2(P2) R291.2(P2) SW4.16 U2.U1(LCD_DATA8)
AM335X_LCD_DATA9: R105.1(P1) R266.2(P2) R293.2(P2) SW4.15 U2.U2(LCD_DATA9)
AM335X_LCD_DATA10: R106.1(P1) R256.2(P2) R294.2(P2) SW4.14 U2.U3(LCD_DATA10)
AM335X_LCD_DATA11: R107.1(P1) R267.2(P2) R281.2(P2) SW4.13 U2.U4(LCD_DATA11)
AM335X_LCD_DATA12: R108.1(P1) R257.2(P2) R282.2(P2) SW4.12 U2.V2(CD_DATA12)
AM335X_LCD_DATA13: R109.1(P1) R258.2(P2) R283.2(P2) SW4.11 U2.V3(LCD_DATA13)
AM335X_LCD_DATA14: R110.1(P1) R260.2(P2) R284.2(P2) SW4.10 U2.V4(LCD_DATA14)
AM335X_LCD_DATA15: R111.1(P1) R254.2(P2) R285.2(P2) SW4.9 U2.T5(LCD_DATA15)
AM335X_LCD_HSYNC: R272.2(P2) R311.2(P2) U2.R5(LCD_HSYNC)
AM335X_LCD_PCLK: R269.2(P2) R307.2(P2) U2.V5(LCD_PCLK)
AM335X_LCD_VSYNC: R271.2(P2) R305.2(P2) U2.U5(LCD_VSYNC)
AM335X_MCASP0_ACLKR: R88.2(P2) R218.2(P2) R379.2(P2) U2.B12(MCASP0_ACLKR)
AM335X_MCASP0_ACLKX: R194.1(P1) R346.1(P1) R448.1(P1) U2.A13(MCASP0_ACLKX)
AM335X_MCASP0_AHCLKR: R85.2(P2) R211.1(P1) R328.1(P1) R452.1(P1) U2.C12(MCASP0_AHCLKR)
AM335X_MCASP0_AHCLKX: R92.2(P2) R234.2(P2) R319.2(P2) R352.1(P1) U2.A14(MCASP0_AHCLKX)
AM335X_MCASP0_AXR0: R203.1(P1) R347.1(P1) R451.1(P1) U2.D12(MCASP0_AXR0)
AM335X_MCASP0_AXR1: R227.2(P2) R318.2(P2) R348.1(P1) U2.D13(MCASP0_AXR1)
AM335X_MCASP0_FSR: R90.2(P2) R224.2(P2) R336.1(P1) U2.C13(MCASP0_FSR)
AM335X_MCASP0_FSX: R199.1(P1) R335.1(P1) R449.1(P1) U2.B13(MCASP0_FSX)
AM335X_MMC2_CLK: R459.1(P1) U28.9(CLKA)
AM335X_MMC2_CMD: R460.1(P1) U28.4(CMDA)
AM335X_MMC2_D0: R456.1(P1) U28.6(DAT0A)
AM335X_MMC2_D1: R457.1(P1) U28.7(DAT1A)
AM335X_MMC2_D2: R458.1(P1) U28.1(DAT2A)
AM335X_MMC2_D3: R491.1(P1) U28.3(DAT3A)
AM335X_MMC_CLK: R197.2(P2) R398.2(P2) U2.G17(MMC0_CLK)
AM335X_MMC_CMD: R200.2(P2) R397.2(P2) U2.G18(MMC0_CMD)
AM335X_MMC_D0: R204.2(P2) R399.2(P2) U2.G16(MMC0_DAT0)
AM335X_MMC_D1: R212.2(P2) R400.2(P2) U2.G15(MMC0_DAT1)
AM335X_MMC_D2: R215.2(P2) R401.2(P2) U2.F18(MMC0_DAT2)
AM335X_MMC_D3: R219.2(P2) R396.2(P2) U2.F17(MMC0_DAT3)
AM335X_OSC0_IN: C4.1 R7.2(P2) U2.V10(XTALIN) Y2.3
AM335X_OSC0_OUT: R8.1(P1) U2.U11(XTALOUT)
AM335X_OSC1_IN: C2.2 U2.A6(RTC_XTALIN) Y1.4
AM335X_OSC1_OUT: R5.1(P1) U2.A4(RTC_XTALOUT)
AM335X_PORZ: U2.B15(PWRONRSTN) U3.4(Y)
AM335X_RTC_PORZ: R4.2(P2) U1.4(Y) U2.B5(RTC_PWRONRSTN) U33.4(B)
AM335X_SPI0_CS0: R55.2(P2) R176.2(P2) R313.2(P2) R552.1(P1) U2.A16(SPI0_CS0)
AM335X_SPI0_CS1: R78.2(P2) R208.1(P1) R380.2(P2) U2.C15(SPI0_CS1)
AM335X_SPI0_D0: R205.1(P1) R436.1(P1) U2.B17(SPI0_D0)
AM335X_SPI0_D1: R56.2(P2) R177.1(P1) R314.2(P2) R553.1(P1) U2.B16(SPI0_D1)
AM335X_SPI0_SCLK: R201.1(P1) R438.1(P1) U2.A17(SPI0_SCLK)
AM335X_UART0_CTSN: R61.2(P2) R213.1(P1) R364.2(P2) U2.E18(UART0_CTSN)
AM335X_UART0_RTSN: R62.2(P2) R216.1(P1) R362.2(P2) U2.E17(UART0_RTSN)
AM335X_UART0_RXD: R220.1(P1) R249.2(P2) R363.2(P2) U2.E15(UART0_RXD)
AM335X_UART0_TXD: R222.1(P1) R244.2(P2) R361.2(P2) U2.E16(UART0_TXD)
AM335X_UART1_CTSN: R84.2(P2) R225.1(P1) R357.1(P1) R445.1(P1) R555.1(P1) U2.D18(UART1_CTSN)
AM335X_UART1_RTSN: R87.2(P2) R229.1(P1) R355.1(P1) R443.1(P1) R554.1(P1) U2.D17(UART1_RTSN)
AM335X_UART1_RXD: R89.2(P2) R232.1(P1) R356.1(P1) U2.D16(UART1_RXD)
AM335X_UART1_TXD: R91.2(P2) R236.1(P1) R354.1(P1) U2.D15(UART1_TXD)
AM335X_USB0_CE: TP23.1 U2.M15(USB0_CE)
AM335X_USB0_DRVVBUS: R383.1(P1) U2.F16(USB0_DRVVBUS) U22.4(EN)
AM335X_USB0_VBUS: D9.1(CATHODE) R563.2 U2.P15(USB0_VBUS)
AM335X_USB1_CE: TP36.1 U2.P18(USB1_CE)
AM335X_USB1_DRVVBUS: R387.1(P1) U2.F15(USB1_DRVVBUS) U29.4(EN)
AM335X_USB1_VBUS: D10.1(CATHODE) R564.2 U2.T18(USB1_VBUS)
AM335X_VDDA_ADC: C63.1 R501.1(I1) U2.D8(VDDA_ADC)
AM335X_VDDS: C48.1 C50.1 C89.1 C96.1 C249.1 R498.1(I1) U2.E6(VDDS#E6) U2.E14(VDDS#E14) U2.F9(VDDS#F9) U2.K13(VDDS#K13) U2.N6(VDDS#N6) U2.P9(VDDS#P9) U2.P14(VDDS#P14)
AM335X_VDDS_DDR: C76.1 C77.1 C78.1 C79.1 C80.1 C82.1 C233.1 R508.2(I2) U2.E5(VDDS_DDR#E5) U2.F5(VDDS_DDR#F5) U2.G5(VDDS_DDR#G5) U2.H5(VDDS_DDR#H5) U2.J5(VDDS_DDR#J5) U2.K5(VDDS_DDR#K5) U2.L5(VDDS_DDR#L5)
AM335X_VDDSHV1: C31.1 C32.1 C258.1 R493.1(I1) U2.P7(VDDSHV1#P7) U2.P8(VDDSHV1#P8)
AM335X_VDDSHV2: C90.1 C92.1 C259.1 R545.1(I1) U2.P10(VDDSHV2#P10) U2.P11(VDDSHV2#P11)
AM335X_VDDSHV3: C93.1 C94.1 C273.1 R546.1(I1) U2.P12(VDDSHV3#P12) U2.P13(VDDSHV3#P13)
AM335X_VDDSHV4: C42.1 C43.1 C274.1 R494.1(I1) U2.H14(VDDSHV4#H14) U2.J14(VDDSHV4#J14)
AM335X_VDDSHV5: C45.1 C46.1 C257.1 R495.1(I1) U2.K14(VDDSHV5#K14) U2.L14(VDDSHV5#L14)
AM335X_VDDSHV6: C25.1 C27.1 C28.1 C29.1 C30.1 C47.1 C247.1 R496.1(I1) U2.E10(VDDSHV6#E10) U2.E11(VDDSHV6#E11) U2.E12(VDDSHV6#E12) U2.E13(VDDSHV6#E13) U2.F14(VDDSHV6#F14) U2.G14(VDDSHV6#G14) U2.N5(VDDSHV6#N5) U2.P5(VDDSHV6#P5) U2.P6(VDDSHV6#P6)
AM335X_XDMA_EVENT_INTR0: R76.2(P2) R221.2(P2) R349.1(P1) TP31.1 U2.A15(XDMA_EVENT_INTR0)
AM335X_XDMA_EVENT_INTR1: R77.2(P2) R228.2(P2) R250.2(P2) R315.2(P2) R351.1(P1) TP32.1 U2.D14(XDMA_EVENT_INTR1)
CAP_VBB_MPU: C72.1 U2.C10(CAP_VBB_MPU)
CAP_VDD_SRAM_CORE: C60.1 U2.D9(CAP_VDD_SRAM_CORE)
CAP_VDD_SRAM_MPU: C71.1 U2.D11(CAP_VDD_SRAM_MPU)
COM_AUD_CLK: J11.52 R338.2(P2)
COM_AUD_FSYNC: J11.54 R339.2(P2)
COM_AUD_IN: J11.56 R340.2(P2)
COM_AUD_OUT: J11.58 R341.2(P2)
COM_BTRST: J11.89 R353.1(P1)
COM_BTUARTCTS: J11.70 R344.2(P2)
COM_BTUARTDEBUG: J11.76 TP45.1
COM_BTUARTRTS: J11.72 R345.2(P2)
COM_BTUARTRX: J11.68 R343.2(P2)
COM_BTUARTTX: J11.66 R342.2(P2)
COM_GNSS_PPS_OUT: J11.50 U14.10(2B2)
COM_GNSS_TIME_STAMP: J11.48 U13.10(2B2)
COM_SDIO_CLK: J11.20 R334.1(P1) R485.2(P2)
COM_SDIO_CMD: J11.24 R333.1(P1) R486.2(P2)
COM_SDIO_D0: J11.26 R332.1(P1) R487.2(P2)
COM_SDIO_D1: J11.28 R331.1(P1) R488.2(P2)
COM_SDIO_D2: J11.30 R330.1(P1) R489.2(P2)
COM_SDIO_D3: J11.32 R329.1(P1) R490.2(P2)
COM_SLOW_CLK: J11.1 U15.12(1B2)
COM_WL_IRQ: J11.34 R337.2(P2)
COM_WL_RS232_RX: J11.13 TP43.1
COM_WL_RS232_TX: J11.11 TP42.1
COM_WL_RST: J11.4 R327.2(P2)
COM_WL_UART_DBG: J11.15 TP44.1
COMAUD_CLK: R338.1(P1) U14.13(1B1)
COMAUD_FSYNC: R339.1(P1) U13.11(2B1)
COMAUD_IN: R340.1(P1) U14.12(1B2)
COMAUD_OUT: R341.1(P1) U14.11(2B1)
COMBTRST: R353.2(P2) U15.10(2B2)
COMBTUARTCTS: R344.1(P1) U16.12(1B2)
COMBTUARTRTS: R345.1(P1) U16.10(2B2)
COMBTUARTRX: R343.1(P1) U16.13(1B1)
COMBTUARTTX: R342.1(P1) U16.11(2B1)
COMWL_IRQ: R337.1(P1) U13.13(1B1)
COMWL_RST: R327.1(P1) U15.13(1B1)
DDR_A0: R18.2(P2) U8.H8(A0) U31.H8(A0)

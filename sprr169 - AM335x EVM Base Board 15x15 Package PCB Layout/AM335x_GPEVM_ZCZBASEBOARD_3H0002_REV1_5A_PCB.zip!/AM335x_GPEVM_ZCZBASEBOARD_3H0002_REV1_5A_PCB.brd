# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_REV1_5A_PCB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_ETH: length 22.4
  TOP w0.508: C271.2 J15.SHLD2 J15.SHLD1 C272.2
GND_OSC0: length 14.5
  TOP w0.254: v1(100.29,83.02) 100.29,84.19 98.58,85.89 95.19,85.89 94.23,86.85 93.53,86.85 93.12,86.44 92.31,86.44 92.07,86.2 U2.V11 ; C5.2 101.64,82.08 v1(101.64,81.83) 101.64,81.57 102.02,81.19 C4.2
  BOTTOM w0.254: v1(100.29,83.02) 100.6,82.71 100.62,82.71 C67.2 101,82.33 101.13,82.33 v1(101.64,81.83)
GND_OSC1: length 13.8
  TOP w0.102: U2.A5 77.94,81.14 77.1,81.14
  TOP w0.121: C3.1 C2.1 67.56,79.92 71.31,79.92 71.56,80.16 75.24,80.16 76.22,81.14 77.1,81.14
GNDA_ADC: length 44.3
  TOP w0.305: v2(81,83.4) U2.E8
  TOP w0.508: v1(49.44,75.73) v1(57.19,75.73) ; R45.1 64.41,84.75 v1(64.17,84.5) 64.16,84.49 59.92,84.49 59.66,84.75 v1(58.9,84.75)
  BOTTOM w0.127: v2(81,83.4) 80.54,83.86 80.05,83.86 79.79,83.6 79.79,83.22 79.56,82.99
  BOTTOM w0.152: 79.56,82.99 79.13,82.99 79.03,83.1 77.15,83.1
  BOTTOM w0.508: v1(57.19,75.73) 57.19,79.03 58.88,80.73 58.88,81.93 58.89,81.93 58.89,84.73 v1(58.9,84.75) ; C63.2 v1(49.44,75.73) ; 77.15,83.1 76.04,83.1 FB10.1 74.46,82.77 74.46,82.97 74.08,83.35 73.06,83.35 72.16,84.25 71.27,84.25 71.03,84.49 R461.1 64.19,84.49 v1(64.17,84.5)
GNDA_TSC: length 61.2
  TOP w0.121: v1(43.29,80.4) 43.61,80.09 43.61,80.07 44.4,79.27 46.69,79.27 47.98,80.56 53.95,80.56 57.12,83.73 R45.2 ; 49.82,57.31 J9.11
  TOP w0.508: C12.2 C11.2 C14.2 C13.2 R51.2 65.19,83.48 R45.2
  BOTTOM w0.121: v1(43.29,80.4) 42.18,79.29 42.18,71.38 47.73,65.83 50.07,65.83 51.22,64.68 51.22,57.57 50.96,57.31 49.82,57.31
GNDUSB0: length 26
  TOP w0.635: v1(124.62,168.26) 124.91,168.55 J14.S4 126.62,166.82 126.87,166.57 126.87,166 J14.S2 ; J14.S1 134.08,166 134.82,166.74 J14.S3 136.66,168.55 v1(136.94,168.26) FB14.2
  BOTTOM w0.635: v1(124.62,168.26) v1(136.94,168.26)
GNDUSB1: length 16.7
  TOP w0.635: J18.S1 154.6,165.66 FB19.2
  BOTTOM w0.635: J18.S1 151.94,168.31 139.98,168.31 J18.S2
GNDUSBJ: length 24.9
  TOP w0.635: J40.S1 3.98,103.06 3.37,103.67 1.52,103.67 ; v1(1.64,105.52) 1.64,103.79 1.52,103.67 ; 1.52,103.67 J40.S3 ; J40.S2 3.98,96.05 3.3,95.38 J40.S4 1.64,95.17 v1(1.64,93) 2.02,92.62 FB25.1
  BOTTOM w0.635: v1(1.64,93) v1(1.64,105.52)
V1_2D: length 3.7
  TOP w0.121: 149.28,16.82 149.26,16.8
  TOP w0.381: C159.1 150.47,17.88 U12.5 149.28,16.82
  BOTTOM w0.762: C242.1 152.8,17.58 v1(152.95,17.31)
V1_2D_EN: length 2.8
  TOP w0.381: v1(147.61,20.74) 147.98,20.37 U12.3
  BOTTOM w0.121: v1(147.61,20.74) 147.36,20.48 147.36,19.98 147.1,19.72 R478.1
V1_8D: length 285.7
  TOP w0.279: U28.17 23.77,105.64 v1(23.84,105.57)
  TOP w0.305: v1(4.36,129.2) 4.74,128.82 J11.62 ; v1(4.36,111.42) 4.61,111.67 J11.8 ; U14.16 v1(21.87,122.48) ; v1(21.86,116.24) 21.74,116.13 U13.16 ; U16.16 v1(21.87,128.83) ; U15.16 v1(21.87,135.18)
  TOP w0.508: 23.91,140.75 18.96,145.71 18.96,147.48 18.2,148.25 16.17,148.25 14.13,150.28 R358.2 ; 23.91,140.75 23.28,140.12 23.28,135.93 22.53,135.18 v1(21.87,135.18) ; 23.91,140.75 26.96,140.75 27.6,140.12 30.39,140.12 34.96,135.55 41.44,135.55 42.58,134.41 50.94,134.41 51.65,135.11 54.23,135.11 57.23,132.12 61.38,132.12 62.52,130.97 66.21,130.97 66.59,130.59 80.67,130.59 84.67,134.6 86.85,134.6 87.44,134.01 97.3,134.01 97.44,134.15 97.94,134.15 98.05,134.26 104.2,134.26 104.87,133.59 118.19,133.59 119.72,132.05 v1(120.18,132.05) 129.37,132.05 131.49,129.93 134.33,129.93 v1(135.8,128.46) C133.1 ; v1(21.87,128.83) 21.87,128.43 21.62,128.18 19.47,128.18 16.65,131 5.52,131 4.36,129.83 v1(4.36,129.2) ; v1(133.01,50.52) 130.53,50.52 128.37,48.36 120.88,48.36 119.44,46.93 v1(116.42,46.93)
  LY3 w0.508: v1(17.39,105.14) 17.99,105.14 18.27,104.86 23.13,104.86 v1(23.84,105.57)
  LY4 w0.483: 133.56,86.52 J8.2 132.75,87.13
  LY4 w0.514: J3.1 135.8,125.28 ; J3.1 134.89,124.37 ; J3.1 135.8,123.46 ; J3.1 136.71,124.37
  BOTTOM w0.305: R330.2 v1(4.48,121.45) ; R334.2 v1(4.61,112.31) ; R332.2 R331.2 v1(4.61,118.02) ; R329.2 v1(4.48,123.74)
  BOTTOM w0.381: R333.2 3.59,114.59
  BOTTOM w0.508: R519.2 19.72,117.51 ; 19.72,117.51 19.72,116.62 19.97,116.37 ; 19.72,117.51 19.72,120.31 20.35,120.93 20.35,122.72 ; 4.23,112.31 3.59,112.31 3.59,118.02 ; 4.23,112.31 4.23,111.54 v1(4.36,111.42) 3.21,111.42 C162.1 ; 4.23,112.31 v1(4.61,112.31) ; v1(17.39,105.14) 17.33,105.14 16.87,105.6 16.87,109.71 17.77,110.6 17.77,114.69 18.3,115.23 19.52,115.23 19.97,115.68 19.97,116.37 ; v1(23.84,105.57) 23.66,105.75 C87.1 ; v1(21.86,116.24) 21.75,116.24 21.63,116.37 C164.1 19.97,116.37 ; 3.59,121.45 3.59,123.74 ; 3.59,121.45 3.59,118.02 ; 3.59,121.45 v1(4.48,121.45) ; 3.59,123.74 v1(4.48,123.74) ; 3.59,123.74 3.59,128.43 v1(4.36,129.2) ; C138.1 132.63,86.65 J8.2 ; R472.1 116.33,47.02 v1(116.42,46.93) 115.18,46.93 C261.1 ; 3.59,118.02 v1(4.61,118.02) ; J3.1 v1(135.8,128.46) ; 20.23,129.07 19.98,129.32 19.98,134.91 20.48,135.42 C168.1 21.63,135.42 v1(21.87,135.18) ; 20.23,129.07 20.23,128.56 19.98,128.31 19.98,123.09 20.35,122.72 ; 20.23,129.07 C170.1 21.63,129.07 v1(21.87,128.83) ; v1(21.87,122.48) 21.63,122.72 20.35,122.72
V1_8FTDI: length 36.3
  TOP w0.254: U58.64 11.27,82.76 v1(11.34,82.69) ; v1(18.81,82.74) 18.81,83.93 U58.49 ; U58.37 v1(19.37,76.52)
  TOP w0.305: 13.65,76.77 13.4,76.52 U58.12 8.04,76.52 v1(8.01,76.49) 7.61,76.08 7.61,75.4 6.92,74.71 v1(6.08,74.71) C330.1 ; 13.65,76.77 13.78,76.9 18.99,76.9 v1(19.37,76.52) ; 13.65,76.77 13.65,78.85 13.47,79.02 13.47,80.56 ; 13.47,80.56 16.62,80.56 v1(18.81,82.74) ; 13.47,80.56 v1(11.34,82.69)
  BOTTOM w0.254: C324.1 20.2,76.52 v1(19.37,76.52) ; v1(18.81,82.74) 18.71,82.84 C316.1 ; C327.1 v1(8.01,76.49) ; C321.1 v1(11.34,82.69)
V3_3D: length 237.9
  TOP w0.203: U25.4 29.27,56.16 29.05,56.37 28.65,56.37 28.62,56.34 28.34,56.34 v1(28.15,56.16) 27.49,56.16 C191.1
  TOP w0.254: v1(10.83,51.04) 10.45,51.42 U60.5 ; U32.6 v1(66.86,33.53)
  TOP w0.381: U55.5 v1(6.75,55.6) ; v1(29.91,67.37) 27.32,67.37 26.35,66.41 19.6,66.41 19.42,66.59 17.06,66.59 v1(16.55,67.09) R593.1 ; C140.1 50.08,65.7 49.82,65.44 49.82,63.66 ; C319.2 v1(10.83,51.04) ; FB15.1 v1(23.91,47.79) ; C318.2 v1(6.03,54.67)
  TOP w0.508: C222.1 67.09,32.61 66.86,32.84 v1(66.86,33.53) ; v1(75.09,146.34) 92.11,146.34 94.91,149.14 111.8,149.14 112.43,149.77 113.98,149.77 114.74,150.53 116.05,150.53 123.19,143.39 128.71,143.39 129.96,142.15 135.95,142.15 137.22,140.88 155.99,140.88 156.88,141.77 R386.2 ; U54.3 v1(19.79,95.6)
  TOP w0.635: v1(48.3,47.92) 50.33,45.88 57.82,45.88 59.03,44.68 63.09,44.68 v1(64.3,45.88) ; v1(46.97,38.7) 58.52,38.7 ; 58.52,38.7 58.97,39.15 v1(65.95,39.15) v1(71.03,39.15) v1(73.57,39.15) ; 58.52,38.7 58.52,35.73 R544.2 58.77,35.1 59.94,33.93 C359.1 64.65,32.93 64.74,32.84 66.86,32.84
  LY4 w0.514: 47.26,137.07 J5.39 ; J5.39 48.17,137.98 ; J5.39 49.08,137.07 ; J5.39 48.17,136.16 ; 69.76,124.73 J6.15 ; J6.15 70.67,125.64 ; J6.15 69.76,126.55 ; J6.15 68.85,125.64 ; 49.82,64.27 49.82,63.66 50.63,63.66
  BOTTOM w0.254: C215.1 65.59,46.03 U27.6
  BOTTOM w0.381: C191.1 28.14,56.17 v1(28.15,56.16) ; v1(10.83,51.04) v1(12.61,51.04)
  BOTTOM w0.508: v1(64.3,45.88) 64.3,46.26 64.07,46.48 64.07,47.37 65.06,48.36 65.06,49.16 65.85,49.95 C358.1 ; J6.15 69.76,124.24 C134.1 ; C135.1 v1(48.93,135.29)
  BOTTOM w0.635: 73.57,40.42 v1(73.57,39.15) ; R454.2 v1(71.03,39.15) ; v1(46.97,38.7) v1(46.97,47.86) ; R455.2 v1(65.95,39.15) ; C215.1 v1(64.3,45.88)
  BOTTOM w0.762: R68.1 107.61,45.06 107.66,45.01 107.66,42.73 107.33,42.4 107.32,42.4 106.87,41.96 106.87,41.95 105.75,40.83 105.75,28.41 102.91,25.56 v1(102.91,22.26)
  vias: v1(113.45,24.55) v1(113.45,23.66) v1(113.45,22.77)
V3_3ETHJCK: length 8.3
  TOP w0.508: J15.2 23.79,12.61 23.15,13.25 TP51.1
V3_3FTDI: length 23.4
  TOP w0.254: U58.31 v1(18.27,73.93) ; v1(17.92,82.61) 18.27,82.96 U58.50 ; U58.20 v1(12.77,73.91) ; U58.56 15.28,83.97 v1(15.28,82.61) ; U58.42 v1(19.46,79.02)
  TOP w0.508: U61.6 v1(12.48,96.3) 12.48,97.19 C334.1 ; U61.8 v1(9.94,96.33) ; v1(16.8,96.71) U54.5 17.88,97.25 17.69,97.44 17.69,98.07 17.83,98.21 C311.1 ; R588.2 v1(14.64,88.84)
  TOP w0.635: FB23.2 FB24.2 v1(1.97,77.89)
  BOTTOM w0.508: R585.2 C331.2 v1(14.39,74.84) ; C322.1 18.27,73.11 v1(18.27,73.93) ; v1(12.77,73.91) 12.77,73.15 C317.1 ; v1(19.46,79.02) 20.35,79.02 C325.1 ; C328.1 v1(15.28,82.61)
V5_0D: length 79.5
  TOP w0.121: U24.E2 U24.E1
  TOP w0.381: J7.2 J7.1 ; U11.11 v1(136.19,12.1)
  TOP w0.508: v1(132.63,126.78) C132.1
  TOP w0.635: 136.05,146.79 134.78,146.79 U22.2 ; 136.05,146.79 143.1,146.79 ; 136.05,146.79 U22.3 ; 144.37,146.79 143.1,146.79 ; 144.37,146.79 U29.3 ; 144.37,146.79 148.64,146.79 C270.1 ; 143.1,146.79 U29.2
  TOP w0.762: J7.2 137.71,86.52 139.23,88.05 C137.1
  TOP w1.27: v1(142.96,4.48) 142.18,5.27 133.62,5.27 133.01,5.88 v1(133.01,10.32)
  LY4 w0.483: 135.11,86.52 J7.1 135.93,87.13 ; 137.2,87.13 J7.2 138.01,86.52
  LY4 w0.514: J3.2 133.26,125.28 ; J3.2 132.35,124.37 ; J3.2 133.26,123.46
  BOTTOM w0.381: 148.12,147.1 148.37,147.1
  BOTTOM w0.508: v1(132.63,126.78) 133.26,126.15 J3.2 ; 148.37,147.1 v1(149.52,148.25)
  BOTTOM w0.635: 133.01,12.1 133.01,12.1 v1(136.19,12.1) 136.19,13.11 C157.1
  BOTTOM w0.762: C136.1 134.66,86.52 J7.1 ; v1(142.96,4.48) R275.2 R276.2
  BOTTOM w1.27: v1(133.01,10.32) 133.01,16.17 v1(132.24,16.93) 132.24,18.2 128.43,22.01 v1(128.43,26.2)
V5_0D_EN: length 1.6
  TOP w0.121: U24.A4 156.79,144.78 R386.1
V5_0HDMICONN: length 5.8
  TOP w0.305: v1(143.66,9.77) J10.18
  TOP w0.381: U11.13 143.5,11.49 144.41,11.49 v1(144.82,11.09)
  BOTTOM w0.635: C158.1 v1(144.82,11.09) 144.9,11.01
  BOTTOM w0.762: 144.9,11.01 v1(143.66,9.77)
VBAT: length 301.9
  TOP w0.121: U24.A1 U24.A2
  TOP w0.203: v1(90.53,37.63) 90.45,37.55 U4.28 ; v1(93.33,36) 93.07,35.75 93.07,35.7 92.87,35.49 U4.23 ; v1(89.16,29.4) 89.16,29.6 89.25,29.68 U4.6 ; v1(87.67,29.48) 87.67,29.5 88.02,29.85 88.02,30.15 88.05,30.18 U4.3 ; 85.51,34.29 U4.41 ; 85.67,31.44 85.67,31.7 85.87,31.89 U4.47 ; 93,31.49 U4.13 ; U4.36 87.25,37.01 87.11,37.15
  TOP w0.381: 93,31.49 93.34,31.15 v1(93.61,31.15) ; v1(149.39,20.74) 149.28,20.63 U12.1 ; 87.11,37.15 86.97,37.29 86.97,37.57 v1(86.91,37.63) ; v1(59.73,99.99) 60.3,99.99 60.55,100.24 61.47,100.24 61.56,100.14 61.76,100.14 62.14,99.76 C8.1 ; v1(85.29,34.29) 85.51,34.29 ; 85.67,31.44 85.25,31.03 85.25,30.02 v1(85.25,30.01) ; R239.2 v1(126.91,79.79)
  TOP w0.502: 88.81,19.32 TP25.1 ; TP25.1 87.77,20.36 ; TP25.1 89.85,20.36 ; TP25.1 88.81,21.4 ; SW1.2 79.06,10.2 ; SW1.2 77.23,10.2 ; SW1.2 78.14,9.28 ; SW1.2 78.14,11.11
  TOP w0.508: C238.1 86.3,39.66 86.6,39.36 86.6,37.93 v1(86.91,37.63) ; C312.1 17.88,91.78 v1(17.88,93.13) U54.1 ; U63.6 63.6,100.05 63.16,99.61 C8.1 ; R629.2 v1(14.9,16.17)
  TOP w0.635: 14.77,151.55 C173.1 12.08,151.55 U17.2
  TOP w0.762: C139.1 129.61,85.76 129.96,86.11 129.96,86.14 130.34,86.52 J8.1 ; C214.1 v1(107.86,158.28)
  TOP w1.016: v1(142.02,20.61) 142.15,20.48 143.04,20.48 144.56,22.01 148.88,22.01 149.39,21.5 v1(149.39,20.74) ; v1(18.73,167.04) v1(18.73,165.31) 18.73,161.97 18.71,161.95 18.71,157.02 19.66,156.07 21.86,156.07 23.28,154.65 23.28,152.54 ; 23.28,152.54 21.92,151.18 15.13,151.18 14.77,151.55 ; 23.28,152.54 v1(33.31,152.54) v1(33.31,151.14)
  LY3 w0.508: v1(31.91,101.51) 28.87,98.46 20.23,98.46 17.88,96.11 v1(17.88,93.13) ; v1(14.9,16.17) 15.66,16.17 16.55,17.06 23.91,17.06 25.69,18.83 44.74,18.83 45.5,19.6 47.92,19.6 50.96,22.64 v1(51.98,22.64)
  LY3 w1.016: v1(63.54,123.23) 59.82,123.23 59.71,123.33 49.31,123.33 48.4,124.24 40.04,124.24 39.13,123.33 34.56,123.33 33.95,122.72 v1(31.91,122.72)
  LY4 w0.483: 131.48,87.13 J8.1 130.67,86.52
  LY4 w0.508: v1(59.73,99.99) 56.93,102.78 52.74,102.78 52.23,103.29 50.46,103.29
  LY4 w0.514: 87.77,20.36 TP25.1 ; TP25.1 88.81,21.4 ; TP25.1 88.81,19.32 ; TP25.1 89.85,20.36 ; J16.5 108.77,159.93 ; J16.5 107.86,160.84 ; J16.5 107.86,159.02 ; J16.5 106.95,159.93 ; 123.74,61.54 J19.1 ; J19.1 122.82,62.46 ; J19.1 124.65,62.46 ; J19.1 123.74,63.37 ; 122.82,59.92 J19.2 ; J19.2 124.65,59.92 ; J19.2 123.74,59 ; J19.2 123.74,60.83 ; 78.14,9.28 SW1.2 ; SW1.2 78.14,11.11 ; SW1.2 77.23,10.2 ; SW1.2 79.06,10.2
  BOTTOM w0.381: C141.1 64.14,124.15 64.14,124.68
  BOTTOM w0.508: C160.1 v1(149.39,20.74)
  BOTTOM w0.762: 21.5,166.09 R83.2 ; R80.2 34.58,166.28 34.45,166.15 ; R82.2 25.82,165.77 ; 30.26,165.77 R81.2
  BOTTOM w1.016: C253.1 v1(86.91,37.63) 86.91,37.76 ; v1(93.33,36) 94.77,36 C251.1 ; 34.45,166.15 34.07,165.77 21.82,165.77 21.5,166.09 20.61,166.09 19.66,167.04 v1(18.73,167.04) v1(18.73,165.31) ; C252.1 88.72,30.32 89.16,29.88 v1(89.16,29.4) ; C236.1 84.72,27.72 85.64,28.64 85.64,29.63 85.26,30.01 85.25,30.01 v1(85.25,30.01) ; v1(90.53,37.63) 90.53,36.63 C250.1 ; C254.1 87.54,30.43 87.54,29.6 v1(87.67,29.48) ; v1(93.61,31.15) 92.38,31.15 C240.1 ; v1(31.91,101.51) v1(31.91,122.72) 31.91,124.73 33.31,126.12 v1(33.31,151.14) v1(33.31,152.54) ; J6.19 64.14,125.1 64.14,124.68 63.54,124.08 v1(63.54,123.23)
  vias: v1(83.48,20.36) v1(84.75,20.36) v1(85.76,20.36) v1(157.77,148.5) v1(158.53,148.5)
VBUS0_OTG_CAP: length 3.7
  TOP w0.635: C182.1 131.99,153.9 J36.2
VBUS1_OTG_CAP: length 6.6
  TOP w0.502: 153.49,157.71 J37.2 ; J37.2 154.53,158.75 ; J37.2 154.53,156.67
  TOP w0.635: C185.1 J37.2
VDD1_SMPS: length 25
  TOP w0.254: U32.8 v1(67.79,35.15)
  TOP w0.635: 79.39,45 v1(75.54,45) 73.36,45 73.1,44.74 v1(71.79,44.74) v1(71.79,45.38) ; R46.1 73.68,36.85 74.12,36.4 v1(74.91,36.4)
  LY3 w0.514: J19.6 124.65,49.76 ; J19.6 123.74,50.67 ; J19.6 122.82,49.76 ; J19.6 123.74,48.84
  BOTTOM w0.121: C357.1 v1(70.06,35.47)
  BOTTOM w0.635: v1(74.91,36.4) 74.91,44.36 v1(75.54,45)
  vias: v1(80.17,45.33) v1(80.56,45.96) v1(80.94,45.33)
VDD2_SMPS: length 167.9
  TOP w0.381: U63.5 62.9,101 62.52,101.38 C6.1 61.89,100.8 v1(61.8,100.72)
  LY4 w0.508: 69.76,45.25 63.24,45.25 63.11,45.12 59.52,45.12 57.49,47.15 57.49,74.37 58.97,75.85 58.97,80.68 58.27,81.38 58.27,85.01 56.68,86.6 56.68,93.26 57.19,93.77 57.19,97.32 59.14,99.27 59.86,99.27 59.87,99.26 60.56,99.26 61.35,100.06 61.35,100.27 v1(61.8,100.72)
  BOTTOM w0.254: v1(70.01,46.93) 69.51,46.93 69.4,47.03 U27.8
  BOTTOM w0.508: C354.1 69.25,48.93 69.76,48.42 v1(70.52,48.42)
  BOTTOM w1.016: J19.7 122.85,46.33 122.85,46.25 121.45,44.85 121.45,37.5 118.66,34.71 118.66,25.02 112.84,19.21 107.99,19.21 107.48,18.71 94.59,18.71 93.57,17.69 87.46,17.69 86.99,18.16 81.79,18.16 75.57,24.38 75.57,34.1 77.76,36.3 v1(77.76,38.26)
  vias: v1(70.52,47.66) v1(76.62,38.26)
VDD3_SMPS: length 35.3
  TOP w0.508: v1(91.35,45.12) 92.23,45.12 R470.1 92,45.88 v1(91.35,45.88)
  TOP w0.635: J19.8 122.75,43.69 109.99,43.69 108.96,44.72 97.01,44.72 95.99,45.74 C235.1 94.29,45.38 92.5,45.38 R470.1
VDD_CORE: length 64
  TOP w0.305: U2.J12 v2(84.2,87.4)
  TOP w0.381: U2.N9 v2(88.2,84.2) U2.N8 ; v2(86.6,83.4) U2.L8 v2(85.8,83.4) U2.K8 ; U2.G6 v2(82.6,81.8) U2.F6 ; v2(87.4,86.6) U2.M11 ; U2.L6 v2(85.8,81.8) U2.K6 ; v2(86.6,82.6) U2.L7 ; U2.F7 v2(82.6,82.6) U2.G7 ; U2.M13 v2(87.4,88.2) U2.N13 ; v2(82.6,85.8) U2.G10 ; v2(85.8,87.4) U2.K12 ; v2(88.2,87.4) U2.N12 ; U2.H11 v2(83.4,86.6) ; v2(86.6,84.2) U2.L9
  TOP w0.635: C17.1 v1(67.35,73.7)
  TOP w1.016: v1(67.35,73.7) v1(66.9,73.25) v1(66.46,72.81) 65.35,71.7 65.35,71.03 ; C232.1 65.35,71.03 ; 65.35,71.03 65.19,70.86 65.19,69.86 62.01,66.69 62.01,60.92 62.14,60.79 62.14,59.47 63.35,58.26 65.26,58.26 v1(65.89,57.63) v1(66.46,57.06) v1(66.46,56.43) ; R32.2 70.54,45.78 71.16,46.39 73.32,46.39
  BOTTOM w0.381: v2(85.8,87.4) 85.5,87.1 C34.1 ; v2(86.6,84.2) 86.14,84.66 C35.1 ; C19.1 82.6,85.37 v2(82.6,85.8) ; C36.1 88.05,84.35 v2(88.2,84.2) ; C24.1 85.19,83.86 85.65,83.4 v2(85.8,83.4)
  BOTTOM w0.635: 66.2,77 v1(65.06,77) ; C23.1 v1(70.14,72.91)
  BOTTOM w1.016: v1(65.89,57.63) v1(66.46,57.06) v1(66.46,56.43) 66.46,52.77 67.6,51.62 70.5,51.62 71.28,50.84 72.73,50.84 74.97,48.6 v1(74.97,46.65)
  vias: v1(73.57,46.65) v1(74.33,46.01)
VDD_MPU: length 79.2
  TOP w0.381: U2.J13 v2(84.2,88.2) U2.H13 83.74,87.8 83.62,87.92 83.18,87.92 83.06,87.8 U2.G13 v2(82.6,88.2) U2.F13 v2(81.8,87.4) U2.F12 U2.F11 v2(81.8,85.8) U2.F10
  TOP w0.635: v1(73.95,34.81) 73.85,34.71 73.19,34.71 72.68,34.2 R46.2
  LY3 w1.016: v1(62.95,62.37) v1(62.95,63.18) 62.95,63.89 v1(62.93,63.92) 62.93,66 62.84,66.09 62.84,67.33 63.71,68.21 63.71,69.63 63.49,69.86 63.49,77.46 60.92,80.02 60.92,81.09 61.64,81.81 64.92,81.81 64.93,81.83
  LY4 w1.016: v1(73.98,33.26) v1(73.98,34.05) 73.95,34.07 v1(73.95,34.81) 73.95,36.87 75.09,38.01 75.09,42.96 76.43,44.3 76.43,46.44 73.13,49.74 68.84,49.74 62.48,56.1 62.48,61.01 62.95,61.48 v1(62.95,62.37) v1(62.95,63.18) 62.95,63.89 v1(62.93,63.92)
  BOTTOM w0.381: v2(81.8,87.4) 81.8,86.69 C41.1 ; C53.1 81.8,85.15 v2(81.8,85.8) ; C83.1 84.42,87.98 v2(84.2,88.2)
  BOTTOM w0.635: v1(65.32,80.81) 65.44,80.94 66.19,80.94 C246.1 ; 69.38,81.7 70.01,82.33 v1(70.52,82.33) ; C56.1 71.41,81.57 v1(71.67,81.83)
VDD_RTC: length 6
  TOP w0.381: v2(80.2,81.8) U2.D6
  BOTTOM w0.203: v2(80.2,81.8) 80.01,81.8 79.83,81.98 79.83,81.98 79.58,82.23 79.58,82.23 79.54,82.27 79.03,82.27
  BOTTOM w0.508: C65.1 76.58,80.81 76.89,81.13 76.91,81.13 78.05,82.27 79.03,82.27
VDDA1P8V_USB0: length 82.1
  TOP w0.381: v2(88.2,90.6) U2.N16 ; v2(89.8,90.6) U2.R16
  TOP w0.508: v1(116.62,132.63) 103.21,132.63 102.55,133.29 98.58,133.29 98.58,133.15 98.07,132.63 97.33,132.63 97.14,132.83 95.77,132.83 v1(95.54,132.6) ; R502.2 114.72,141.1 114.72,139.67 115.86,138.53 v1(115.86,136.94) C61.1
  LY4 w0.381: v2(88.2,90.6) 88.2,90.61 88.75,91.16 89.24,91.16 v2(89.8,90.6)
  BOTTOM w0.508: v1(116.62,132.63) 116.62,136.18 v1(115.86,136.94) ; v1(95.54,132.6) 95.54,131.48 95.92,131.1 95.92,128.37 95.54,127.99 95.54,116.62 96.05,116.12 96.05,112.43 94.78,111.16 94.78,106.59 95.52,105.85 95.52,103.6 92.92,101.01 92.92,97.78 91.41,96.26 91.41,95.48 90.78,94.84 89.84,94.84 89.06,94.06 89.06,91.6 88.49,91.03 88.49,90.89 v2(88.2,90.6)
VDDA3P3V_USB0: length 76.1
  TOP w0.381: v2(88.2,89.8) U2.N15 ; v2(89.8,89.8) U2.R15
  TOP w0.508: 109.58,137.82 v1(109.59,137.81) ; 109.58,137.82 109.58,137.89 107.58,139.89 R504.2 ; 109.58,137.82 109.58,136.88 C62.1 ; v1(92.87,96.56) 92.87,97.08 94.32,98.52 94.32,102.57 96.4,104.66 v1(108.88,104.66)
  LY3 w0.102: v2(89.8,89.8) 89.79,89.8 ; 91.32,91.35 91.2,91.48
  LY3 w0.127: 90.19,90.19 90.92,90.19 91.05,90.32 91.05,91.2 91.04,91.2 90.32,91.2 90.19,91.07 90.19,90.19 ; 90.19,90.19 90.18,90.18
  LY3 w0.254: 90.18,90.18 v2(89.8,89.8)
  LY3 w0.508: v1(92.87,96.56) 92.87,95.16 91.2,93.48 91.2,91.35 91.05,91.2
  BOTTOM w0.102: 89.19,89.38 88.62,89.38 88.2,89.8 v2(88.2,89.8) 88.58,90.18 89.42,90.18 v2(89.8,89.8) 89.58,89.58 89.39,89.58 89.19,89.38
  BOTTOM w0.508: v1(109.59,137.81) 108.88,137.1 v1(108.88,104.66)
VDDA_ADC: length 153.9
  TOP w0.121: 124.75,160.57 124.74,160.57 124.62,160.69 124.62,160.69
  TOP w0.508: v1(124.37,160.95) 124.75,160.57 R565.2 125.82,160.01 Q5.S ; v1(47.92,78.4) 48.3,78.78 v1(53.76,78.78) ; v1(58.01,86.65) 58.07,86.59 65.32,86.59 v1(65.63,86.91) 65.63,88.34 65.64,88.34 65.64,88.5 R30.1
  LY3 w0.508: v1(112.25,108.85) 90.97,108.85 89.78,107.66 82,107.66 80.68,106.34 80.68,104 79.18,102.5 79.18,98.79 76.49,96.1 73.11,96.1 71.11,94.09 71.11,90.38 70.06,89.34 66.74,89.34 65.63,88.24 v1(65.63,86.91)
  BOTTOM w0.381: v1(65.63,86.91) 65.25,87.29 R462.1
  BOTTOM w0.508: v1(124.37,160.95) 120.79,157.36 120.79,135.44 115.56,130.21 115.56,128.51 114.03,126.99 114.03,125.69 112.25,123.91 v1(112.25,108.85) ; v1(58.01,86.65) 58.01,85.93 58.25,85.69 58.25,82.2 58.25,82.19 58.25,81.11 55.92,78.78 v1(53.76,78.78) 53.7,78.72 FB9.1 ; v1(47.92,78.4) R501.2
VDDH_PHY: length 2.8
  TOP w0.762: C192.1 28.23,53.12 v1(28.49,53.38)
  BOTTOM w0.762: R389.1 v1(28.49,53.38) ; R391.2 26.71,58.2 v1(26.45,57.95)
VDDL_PHY: length 14.7
  TOP w0.203: v1(31.33,59.12) 31.38,59.06 U25.47
  TOP w0.508: R394.1 v1(33.31,62.9) ; FB16.2 27.98,61.8 L7.1 28.51,61.27 C256.1 30.03,61.12 31.28,61.12 C197.1 31.41,60.49 31.28,60.36 31.28,59.17 v1(31.33,59.12)
  BOTTOM w0.508: C196.1 31.53,58.91 v1(31.33,59.12) 31.33,59.65 33.31,61.63 v1(33.31,62.9)
VDDMPU_MON: length 4.7
  TOP w0.381: R561.1 73.95,78.4 76.87,78.4 77.48,79 U2.A2
VDDR_VREF: length 80.1
  TOP w0.381: v1(80.78,63.84) U34.E1 ; v2(84.2,80.2) U2.J4 ; v1(91.38,57.44) U33.J8 ; v1(95.38,63.84) U33.E1 ; v1(76.78,57.44) U34.J8
  TOP w0.508: v1(102.91,59.45) 102.91,60.54 102.41,61.04 v1(100.25,61.04)
  LY4 w0.508: v1(100.25,61.04) 100.25,61.82 99.05,63.03 95.85,63.03 95.38,63.49 v1(95.38,63.84)
  BOTTOM w0.254: C308.1 103.29,58.01 103.66,57.64 U62.6
  BOTTOM w0.381: 77.58,59.73 77.68,59.63 77.79,59.73 ; v2(84.2,80.2) 84.72,80.2 85,79.92 R541.2 84.82,79.26 84.34,78.78 84.34,77.99
  BOTTOM w0.508: v1(102.91,59.45) 103.29,59.07 C308.1 ; v1(91.38,57.44) 91.38,58.16 92.26,59.04 92.26,59.73 ; 80.26,63.84 80.26,65.35 80.58,65.67 80.59,65.67 80.62,65.7 C335.2 ; 80.26,63.84 v1(80.78,63.84) ; 80.26,63.84 79.72,63.84 79.59,63.71 79.59,62.67 79.39,62.48 79.39,61.41 79.35,61.37 79.35,60.56 78.52,59.73 C304.1 77.79,59.73 77.79,58.44 77.58,58.24 ; 92.26,59.73 C307.1 C336.2 94.67,59.73 95.13,60.2 95.13,60.86 94.6,61.39 94.6,63.15 95.14,63.69 95.24,63.69 v1(95.38,63.84) 94.83,64.39 94.83,66.17 93.54,67.46 93.54,67.54 92.6,68.48 89.97,68.48 89.96,68.49 87.92,68.49 84.54,71.87 R542.2 C309.2 C303.1 84.54,75.2 83.99,75.75 83.99,76.97 84.29,77.27 84.29,77.94 84.34,77.99 ; 92.26,59.73 C306.1 v1(90.21,59.73) 89.65,60.29 83.98,60.29 83.43,59.73 81.44,59.73 80.99,59.28 80.99,58.94 80.3,58.24 77.58,58.24 ; 77.58,58.24 77.56,58.24 76.99,57.68 76.99,57.65 v1(76.78,57.44) ; 77.58,59.73 C305.1
VDDR_VTT: length 12.9
  BOTTOM w0.381: C338.1 104.66,51.83 104.66,52.18 v1(104.79,52.31) 104.66,52.44 U62.3
  BOTTOM w0.508: C377.1 88.32,66.97 88.45,67.09 88.68,67.09 R613.1 88.81,67.3 v1(89.32,67.8) ; v1(99.99,53.12) 99.99,52.46 100.48,51.96 C277.1 ; v1(90.33,67.8) 89.83,67.3 R609.1 ; v1(91.32,67.8) 90.84,67.32 R606.1 ; R603.2 v1(102.02,52.74) ; C275.1 v1(99.98,54.03) ; C276.1 v1(98.46,53.12) ; R607.1 91.86,67.35 v1(92.32,67.8) 92.87,67.25 R604.1
  vias: v1(83.96,52.95) v1(85,52.95) v1(85.99,52.95) v1(87.06,52.92) v1(88.18,52.92) v1(89.19,52.92) v1(90.21,52.95) v1(91.27,52.97) v1(92.34,52.97) v1(93.38,52.95) v1(94.42,67.83) v1(94.4,52.95) v1(95.44,67.8) v1(96.48,67.83)
VDDS_DDR: length 93.4
  TOP w0.254: v1(76.14,64.81) 76.14,63.71 76.38,63.47 U34.K1 ; U34.G2 v1(78.38,62.24)
  TOP w0.381: C352.2 v1(99.73,58.08) ; U33.E2 v1(95.38,62.24) ; v1(82.38,63.84) U34.C1 ; v1(97.78,56.64) U33.B9 ; C227.1 88.98,54.6 v1(88.98,56.64) U33.M9 ; C226.1 84.75,55.21 83.98,55.97 v1(83.98,56.64) U34.A9 ; v1(80.78,56.64) U34.E9 ; v1(92.98,57.44) U33.G8 ; v1(74.38,63.84) U34.M1 ; v1(83.18,56.64) U34.B9 ; U33.G2 v1(92.98,62.24) ; U33.A2 v1(98.58,62.24) ; U34.E2 v1(80.78,62.24) ; U34.A2 v1(83.98,62.24) ; v1(88.98,63.84) U33.M1 ; v1(90.58,56.64) U33.K9 ; v1(78.38,57.44) U34.G8 ; v1(96.18,59.04) U33.D7 ; v1(75.98,56.64) U34.K9 ; v1(90.58,63.84) U33.K1 ; v1(81.58,59.04) U34.D7 ; v1(95.38,56.64) U33.E9 ; v1(74.38,56.64) U34.M9 ; v1(98.58,56.64) U33.A9 ; v1(96.98,63.84) U33.C1
  TOP w0.635: R513.2 116.2,40.62 115.29,40.62 v1(114.85,40.17) 114.85,39.66 v1(114.59,39.41)
  LY3 w0.508: v1(114.85,40.17) 114.85,39.66 v1(114.59,39.41)
  LY3 w0.635: v1(114.59,39.41) 104.56,39.41 v1(103.03,40.93) v1(103.03,41.69)
  BOTTOM w0.254: C339.1 105.07,51.61 105.41,51.95 105.41,52.22 v1(105.5,52.31) 105.29,52.51 105.29,52.52 105.16,52.66 U62.2
  BOTTOM w0.381: C189.1 95.38,56.01 v1(95.38,56.64) ; v1(92.98,57.44) 92.98,58.18 C188.1 ; v1(95.38,62.24) 95.38,63 C156.1 ; 88.94,64.68 88.98,64.63 v1(88.98,63.84) ; C181.1 97.47,55.89 97.47,56.32 v1(97.78,56.64) ; C203.1 v1(72.3,56.09) ; v1(81.58,59.04) 81.58,58.45 C126.1 ; v1(75.98,56.64) 75.98,55.8 C220.1 ; v1(90.58,56.64) 90.58,55.8 C174.1 ; C335.1 C217.1 82.38,64.64 v1(82.38,63.84) ; v1(83.98,62.24) 84.33,61.89 C208.1 ; v1(92.98,62.24) 92.98,62.92 C219.1 ; C208.1 85.51,61.63 85.94,61.2 87.11,61.2 R630.2 ; C208.1 C224.1 C225.1 85.51,64.05 ; C155.1 82.86,55.89 82.86,56.32 v1(83.18,56.64) ; v1(67.47,69.18) 68.17,69.18 C267.1 ; C195.1 96.98,64.64 v1(96.98,63.84) ; C218.1 74.38,64.63 v1(74.38,63.84) ; v1(94.55,60.44) 94.25,60.74 C336.1 ; C223.1 80.78,56.01 v1(80.78,56.64) ; C125.1 79.34,54.49 v1(78.9,54.49) 78.9,54.2 78.46,53.76 R631.2 ; C221.1 80.78,63 v1(80.78,62.24) ; C216.1 78.38,62.92 v1(78.38,62.24) ; U64.6 75.73,52.85 75.84,52.74 C18.1 76.24,53.69 76.36,53.82 v1(76.36,54.52)
  BOTTOM w0.508: R597.2 C340.1 v1(110.15,55.33) ; C278.1 v1(108.62,51.8) ; C279.1 v1(106.59,51.8)
  BOTTOM w0.635: v1(103.03,40.93) v1(103.03,41.69) 103.03,42.65 101.8,43.88 100.9,43.88 96.98,47.8 96.98,53.62 96.87,53.72 96.87,54.3 96.98,54.4 96.98,54.53 v1(97.47,55.03) v1(96.58,55.03)
  BOTTOM w0.762: C280.1 v1(101.88,68.76)
VDDS_OSC: length 47.9
  TOP w0.305: U2.R11 v2(89.8,86.6)
  LY4 w0.508: v1(102.97,81.06) 101.38,81.06 101,81.44 101,83.48 100.49,83.98 97.31,83.98 96.17,82.84 94.66,82.84 93.51,84 93.51,85.25 v1(93.79,85.53)
  BOTTOM w0.381: v1(93.79,85.53) 90.87,85.53 v2(89.8,86.6)
  BOTTOM w0.508: C67.1 101.26,81.06 v1(102.97,81.06) 107.02,81.06 110.5,77.58 110.5,65.21 110.72,65 113.54,65 R506.1
VDDS_PLL_CORE_LCD: length 39.4
  TOP w0.102: U2.R10 89.41,85.4
  TOP w0.381: 89.41,85.4 v2(89.8,85.01)
  LY4 w0.508: v2(89.8,85.01) 90.02,85.23 90.02,85.24 90.36,85.58 91.02,85.58 94.4,82.21 97.94,82.21 98.26,81.89 v1(99.35,81.89)
  BOTTOM w0.508: R503.1 107.51,65.67 C64.1 108.78,65.7 109.74,66.65 109.74,77.3 106.62,80.43 100.75,80.43 100.05,81.13 100.05,81.2 99.68,81.57 99.67,81.57 v1(99.35,81.89)
VDDS_PLL_DDR: length 44.3
  TOP w0.381: U2.E7 v2(81,82.6)
  LY3 w0.102: 81,82.59 80.62,82.21 79.92,82.21 79.54,82.59 79.93,82.98 80.61,82.98 80.99,82.6 v2(81,82.6) 81,82.59
  LY3 w0.508: 79.54,82.59 78.65,82.59 75.41,79.35 68.81,79.35 v1(68.24,78.78)
  BOTTOM w0.508: v1(68.24,78.78) 68.24,75.08 68.3,75.02 68.3,73.12 65.7,70.52 65.7,69.51 62.9,66.71 C73.1 62.11,64.85 62.11,61.78 62.12,61.78 62.12,59.45 62.11,59.45 62.11,58.4 59.95,56.23 R507.2
VDDS_PLL_MPU: length 47.7
  TOP w0.102: U2.H15 v2(83.4,89.8)
  TOP w0.508: v1(94.24,117) 94.24,115.86 R497.2
  LY3 w0.508: v1(84.26,113.52) 84.9,113.52 85.19,113.82 91.21,113.82 92.34,112.69 v1(94.27,112.69)
  LY4 w0.102: 83,90.24 83.4,89.84 v2(83.4,89.8) 83.39,89.8 82.97,89.38 82.4,89.38 82.18,89.6 82.18,90.21 ; 83,90.24 82.97,90.21 82.18,90.21 ; 83,90.24 83,91.03 82.49,91.03 82.18,90.72 82.18,90.21
  LY4 w0.508: 83,91.03 83,92.56 82.46,93.1 82.46,94.33 81.78,95.01 81.78,97.46 81.71,97.53 81.71,98.05 81.78,98.12 81.78,98.16 82.09,98.47 82.6,98.47 83.06,98.93 83.06,100.33 83.86,101.13 v1(84.49,101.13)
  BOTTOM w0.508: v1(94.27,112.69) C70.1 94.27,114.34 94.24,114.37 v1(94.24,117) ; v1(84.49,101.13) 84.04,101.58 84.04,106.4 84.26,106.62 v1(84.26,113.52)
VDDS_RTC: length 37.1
  TOP w0.305: v2(80.2,82.6) U2.D7
  BOTTOM w0.508: v1(70.52,81.5) 70.07,81.05 70.07,80.74 68.94,79.61 68.94,72.62 66.33,70.01 66.33,69 64.62,67.28 64.62,61.64 65.06,61.2 C66.1 65.06,59.03 64.43,58.39 64.43,57.06 64.94,56.55 64.94,52.43 64.68,52.17 64.68,50.83 63.74,49.88 63.19,49.88 R505.1
VDDS_SRAM_CORE_BG: length 52.3
  TOP w0.381: v2(81,84.2) U2.E9
  TOP w0.508: v1(50.2,102.53) 51.35,103.67 51.35,103.69 52.59,104.94 64.86,104.94 65.83,103.96 65.83,103.91 66.97,102.78 v1(67.6,102.78)
  BOTTOM w0.102: v2(81,84.2) 80.28,84.2 79.86,84.62 78.84,84.62
  BOTTOM w0.508: 78.84,84.62 78.59,84.37 75.86,84.37 74.53,85.7 73.51,85.7 72.05,87.16 72.05,87.71 71.26,88.5 68.92,88.5 67.44,89.97 67.44,93.35 67.09,93.7 67.09,99 67.19,99.1 67.19,101.61 67.6,102.02 v1(67.6,102.78) ; R500.2 49.11,102.75 49.97,102.75 v1(50.2,102.53) 50.33,102.4 51.09,102.4
VDDS_SRAM_MPU_BB: length 60.9
  TOP w0.381: v2(80.2,85.8) U2.D10
  TOP w0.508: v1(67.22,107.4) 66.36,106.54 58.84,106.54 57.97,107.4 v1(51.93,107.4)
  BOTTOM w0.381: 79.59,86.38 79.96,86.02 79.98,86.02 v2(80.2,85.8)
  BOTTOM w0.508: v1(67.22,107.4) 68.25,106.37 68.25,104.44 68.25,104.44 68.25,101.76 67.82,101.34 67.82,98.83 67.73,98.74 67.73,94.02 68.08,93.67 68.08,90.68 69.62,89.14 71.52,89.14 72.68,87.98 72.68,87.54 73.25,86.97 76.82,86.97 77.41,86.38 79.59,86.38 ; v1(51.93,107.4) 51.93,98.92 C69.1
  BOTTOM w0.635: R499.2 49.28,98.08 v1(50.08,98.08) 50.2,97.95 C69.1
VDDSHV1: length 385.1
  TOP w0.305: v1(147.53,117.66) 147.76,117.44 U9.39 ; U9.12 148.75,97.7 v1(148.37,98.08) ; U9.37 148.76,117.38 v1(148.5,117.64) ; U9.34 v1(150.26,117.66)
  TOP w0.381: U15.3 25.02,136.48 24.7,136.16 v1(24.7,136.05) 24.93,135.83 U15.2 ; v1(24.65,135.01) 24.81,135.18 U15.1
  TOP w0.635: v1(148.37,98.08) 148.37,98.31 147.76,98.92 145.66,98.92 v1(145.57,98.82) ; v1(148.37,95.29) 148.5,95.16 C128.1 148.5,93.84 148.86,93.48 152.64,93.48 153.45,94.3 v1(153.45,95.64) ; v1(147.53,117.66) 147.53,118.45 C131.1 C130.1 150.48,118.45 150.48,117.89 v1(150.26,117.66)
  TOP w0.762: v1(27.22,83.35) 42.35,83.35 45.45,86.45 v1(47.92,86.45) 54.09,86.45 v1(54.65,85.89) ; v1(145.64,141.96) 140.54,141.96 139.38,143.12 130.61,143.12 129.03,144.69 123.81,144.69 117.11,151.4 114.31,151.4 113.55,150.63 112.08,150.63 111.34,149.9 93.38,149.9 90.84,147.36 73.95,147.36 73.32,146.72 69.68,146.72 66.15,150.25 63.64,150.25 62.62,151.27 59.37,151.27 56.73,153.91 31.2,153.91 30.45,154.66 v1(25.12,154.66)
  LY3 w0.635: v1(119.51,72.58) 119.54,72.58 122.43,69.7 147.29,69.7 150.95,73.35 150.95,87.45 151.68,88.18 151.68,93.86 v1(153.45,95.64)
  BOTTOM w0.635: R130.2 v1(153.45,95.64) ; C129.1 v1(148.5,117.64) ; v1(148.37,95.29) 148.5,95.41 C127.1 148.5,97.95 v1(148.37,98.08) ; v1(24.7,136.05) 24.86,136.05 25.5,135.42 C167.1 25.41,135.01 v1(24.65,135.01) ; R493.2 v1(119.51,72.58)
  BOTTOM w0.762: 146.09,96.05 145.58,96.56 R131.2 145.43,97.34 145.43,98.68 v1(145.57,98.82) 145.91,99.17 145.91,99.66 146.52,100.27 146.52,105.19 146.65,105.32 146.65,116.78 v1(147.53,117.66) ; 25.56,129.03 25.56,133.36 25.82,133.62 C167.1 26.58,135.42 27.34,136.18 27.34,137.32 ; 25.56,129.03 25.56,124.24 25.44,124.12 25.44,119.74 27.18,117.99 27.18,114.89 27.09,114.8 27.09,107.04 27.12,107 27.12,105.97 27.02,105.87 27.02,97.89 26.58,97.45 26.58,95.21 26.81,94.98 26.81,88.89 26.58,88.66 26.58,84.06 27.22,83.43 v1(27.22,83.35) ; 25.56,129.03 C169.1 ; v1(147.53,117.66) 147.53,118.99 145.91,120.61 145.91,133.26 146.34,133.69 146.34,137.96 145.64,138.66 v1(145.64,141.96) ; v1(147.53,117.66) 148.47,117.66 v1(148.5,117.64) ; v1(54.65,85.89) 54.65,84.55 FB2.1 FB1.1 ; 27.34,137.32 R518.2 ; 27.34,137.32 27.34,139.74 25.12,141.96 v1(25.12,154.66)
VDDSHV2: length 76.1
  TOP w0.254: U28.5 22.27,111.25 21.63,111.9 C74.1 ; U28.21 26.96,108.37 C15.1
  TOP w0.381: v1(27.85,108.37) C15.1
  TOP w0.508: 27.98,111.67 v1(28.74,111.67) ; C74.1 v1(20.87,112.56)
  TOP w0.635: v1(111.99,100.55) 106.15,100.55 v1(105.75,100.95) ; v1(77.81,119.1) 78,118.91 83.67,118.91 85,120.24 90.78,120.24 91.38,120.84 103.71,120.84 104.05,120.49 104.98,120.49 v1(105.04,120.43)
  BOTTOM w0.635: R545.2 111.64,96.71 FB5.1 v1(111.99,100.55) ; v1(77.81,119.1) 77.81,119.65 77.63,119.82 77.63,119.85 77.05,120.43 77.03,120.43 75.75,121.71 75.75,123.48 75.37,123.86 C148.1 J6.11 ; v1(105.04,120.43) 105.06,120.43 105.57,119.91 105.57,114.4 104.37,113.19 104.37,102.27 105.59,101.05 105.66,101.05 v1(105.75,100.95)
VDDSHV3: length 10
  TOP w0.635: FB20.1 FB21.1 127.86,137.51 128.69,136.69 132.27,136.69 R546.2
VDDSHV4: length 55.8
  TOP w0.254: U19.10 v1(56.87,144.06)
  TOP w0.381: U20.10 v1(71.92,148.12)
  TOP w0.508: C255.1 v1(54.1,145.03) ; J13.19 54.73,147.24 54.46,146.98 v1(54.27,146.98) 54.08,146.98 53.87,147.18 J13.4
  TOP w0.635: v1(128.12,142.28) 128.12,142.28 127.87,142.53 122.97,142.53 115.73,149.77 v1(115.35,149.77)
  BOTTOM w0.635: R494.2 134.37,130.97 133.13,130.97 131.61,132.5 130.91,132.5 FB4.1 130.4,134.85 128.12,137.13 v1(128.12,142.28) ; R371.2 R370.2 46.52,166.28 46.14,165.9 v1(46.14,164.38) ; R373.2 R372.2 56.55,166.28 55.66,165.39 v1(55.66,164.38) ; v1(54.27,146.98) 53.76,147.48 C180.1 ; v1(46.01,149.9) 46.39,149.52 R365.2 ; R369.2 v1(43.09,148.88) ; v1(48.17,149.9) 48.55,149.52 R366.2 R368.2 R367.2
VDDSHV5: length 227.4
  LY3 w0.762: v1(103.06,139.74) 109.77,139.74 111.42,138.09 v1(114.59,138.09) ; v1(24.55,52.62) 24.55,50.71 25.44,49.82 27.72,49.82 28.1,50.2 39.66,50.2 40.15,49.71 50.2,49.71 51.49,48.42 56.81,48.42 58.2,49.82 112.14,49.82 112.97,50.65 112.97,50.74 114.53,52.3 v1(114.53,58.39) ; v1(130.4,128.46) 127.74,128.46 127,129.2 126.37,129.2 126.12,129.45 114.72,129.45 v1(114.59,129.32)
  LY4 w0.762: v1(114.53,58.39) 114.59,58.46 116.75,58.46 117.89,59.6 117.89,63.92 117.75,64.06 117.75,71.04 115.61,73.19 115.61,93.13 114.59,94.14 v1(114.59,129.32) v1(114.59,138.09) ; v1(24.55,52.62) 24.55,58.71 24.17,59.09 v1(24.17,59.85)
  BOTTOM w0.381: R388.2 v1(24.55,52.62)
  BOTTOM w0.508: R409.2 24.55,59.47 v1(24.17,59.85)
  BOTTOM w0.635: FB6.1 v1(114.53,58.39)
  BOTTOM w0.762: FB3.1 v1(130.4,128.46) ; R495.2 v1(103.06,139.74)
VDDSHV6: length 207.8
  TOP w0.381: R568.2 v1(130.87,33.84) ; U7.8 v1(138.4,69) ; v1(24.8,117.64) 25.02,117.43 U13.3 ; U14.2 27.06,123.13 v1(27.47,122.72) 27.23,122.48 U14.1 ; FB12.2 165.58,18.33 166.12,18.33 v1(166.14,18.31) ; v1(144.94,18.33) 144.67,18.6 U11.24 ; v1(77.7,102.45) 77.7,100.94 77.89,100.76 77.89,100.23 77.7,100.05 77.7,99.28 v1(77.99,99) ; R378.2 63.29,145.06 U21.1 ; R567.2 v1(130.87,32.55) ; U16.2 24.96,129.48 v1(24.68,129.2) 25.05,128.83 U16.1 ; R306.2 v1(130.82,31.43) ; D8.2 v1(159.68,17.44) ; R634.2 67.86,102.23 68.17,102.54 68.17,103.02 67.77,103.42 67.73,103.42 v1(67.6,103.54) ; U13.1 25.19,116.13 24.86,115.79 v1(24.85,115.79) ; R570.2 v1(130.82,30.29)
  TOP w0.635: v1(52.93,81.25) 52.23,81.25 52.23,81.25 40.29,81.25 39.92,80.87 v1(25.18,80.87) ; v1(145.33,157.14) 145.33,156.37 144.31,155.36 139.42,155.36 138.71,154.64 138.71,152.24 138.95,151.99 v1(138.98,151.99) R382.1 ; v1(21.37,64.93) 24.68,64.93 25.06,64.55 C213.1 25.05,63.79 U26.5 ; J2.5 v1(22.01,94.27) ; v1(146.09,157.2) 146.09,156.18 146.91,155.36 R412.1 ; R589.2 v1(8.55,49.41) ; R378.2 v1(63.16,145.96)
  LY3 w0.381: v1(70.65,98.84) 70.9,99.1 ; 70.9,99.1 70.52,99.1 69.89,99.73 69.89,101.26 69.25,101.89 69.25,102.46 68.17,103.54 v1(67.6,103.54) 67.03,103.54 66.46,102.97 66.46,98.46 65.82,97.83 55.16,97.83 v1(54.9,98.08) ; 70.9,99.1 71.54,99.73 77.51,99.73 77.99,99.25 v1(77.99,99)
  BOTTOM w0.381: R559.2 v1(10.83,49.31) ; R72.2 v1(139.74,68.87) C116.1 138.59,69 v1(138.4,69) ; R552.2 R553.2 71.03,98.15 70.68,98.5 70.68,98.81 v1(70.65,98.84) ; R548.2 R547.2 78.52,98.46 v1(77.99,99) ; v1(77.7,102.45) 77.7,102.35 77.76,102.3 R554.2 R555.2 ; C149.1 v1(144.94,18.33)
  BOTTOM w0.508: R110.2 R111.2 165.77,73.95 v1(165.82,73.9) ; R104.2 R105.2 v1(165.82,89.19) ; R108.2 R109.2 165.76,79.03 v1(165.82,78.96) ; R98.2 R99.2 v1(165.82,61.51) ; v1(165.82,51.35) R103.2 R102.2 ; R106.2 R107.2 v1(165.9,84.11) ; C243.1 164.88,18.31 v1(166.14,18.31) ; R96.2 R97.2 v1(165.82,66.59) ; v1(165.82,56.43) R101.2 R100.2
  BOTTOM w0.635: v1(24.8,117.64) 25.02,117.42 C163.1 ; 25.18,89.19 25.74,89.19 v1(25.87,89.32) ; 25.18,89.19 R6.2 v1(25.18,80.87) 25.18,69.38 21.37,65.57 v1(21.37,64.93) ; 25.18,89.19 R71.2 ; v1(54.9,98.08) 54.43,97.61 54.43,95.45 53.25,94.27 FB7.1 FB8.1 54.58,90.65 54.58,88.14 54.11,87.67 53.72,87.67 R496.2 52.93,86.88 v1(52.93,81.25) ; v1(27.49,88.3) 28.22,89.02 29.21,89.02 R70.2 ; v1(27.47,122.72) 27.3,122.55 C165.1 ; C115.1 v1(22.01,94.27)
AM335X_AIN0: length 68.1
  TOP w0.102: 77.1,82.59 78.65,82.59 79,82.24 U2.B6
  TOP w0.121: 77.1,82.59 77.07,82.62 73.1,82.62 72.62,83.1 70.4,83.1 69.76,82.46 v1(68.87,82.46) 68.64,82.23 65.94,82.23 65.62,81.9 64.67,81.9 64.57,82.01 60.47,82.01 60.25,82.23 57.11,82.23 54.62,79.74 48.21,79.74 46.74,78.27 41.76,78.27 41.39,77.9 41.32,77.9 v1(41.01,77.58)
  BOTTOM w0.095: 49.82,56.04 49.19,56.68 47.79,56.68
  BOTTOM w0.121: v1(41.01,77.58) 41.01,71.31 47.1,65.21 47.1,57.19 47.61,56.68 47.79,56.68 ; R461.2 v1(68.87,82.46)
AM335X_AIN1: length 77.8
  TOP w0.102: v2(79.4,83.4) U2.C7
  TOP w0.121: v1(43.42,85.53) 43.42,86.55 44.72,87.84 55.36,87.84 57.51,85.69 v1(64.93,85.69)
  BOTTOM w0.095: 49.82,54.77 49.19,55.41 47.79,55.41
  BOTTOM w0.102: 77.1,83.54 77.73,83.54 77.79,83.48 78.84,83.48 78.92,83.4 v2(79.4,83.4)
  BOTTOM w0.121: 47.79,55.41 47.48,55.41 46.19,56.7 46.19,65.16 40.25,71.1 40.25,77.84 40.75,78.34 40.75,80.43 43.11,82.78 43.11,85.22 v1(43.42,85.53) ; R462.2 64.43,86.2 v1(64.93,85.69) 65.31,85.31 65.75,85.31 65.82,85.38 71.16,85.38 71.54,85 74.21,85 75.67,83.54 77.1,83.54
AM335X_AIN2: length 74.8
  TOP w0.102: U2.B7 79,83 78.59,83.41 77.1,83.41
  TOP w0.121: 77.1,83.41 76.55,83.41 76.08,83.89 75.19,83.89 74.21,84.87 70.52,84.87 70.4,84.75 70.4,84.37 69.95,83.92 69.13,83.92 67.93,82.72 66.14,82.72 65.7,82.72 65.38,82.4 64.88,82.4 64.77,82.51 60.87,82.51 60.65,82.72 56.62,82.72 54.2,80.3 48.07,80.3 46.8,79.02 40.78,79.02 40.19,79.62 v1(39.71,79.62)
  BOTTOM w0.095: 49.82,53.5 49.18,54.14 47.91,54.14
  BOTTOM w0.121: v1(39.71,79.62) 39.71,70.52 45.38,64.86 45.38,55.76 47,54.14 47.91,54.14
AM335X_AIN3: length 73.2
  TOP w0.102: 77.1,83 U2.A7
  TOP w0.121: 77.1,83 76.78,83 76.65,82.87 73.2,82.87 72.72,83.35 71.49,83.35 71.23,83.6 69.16,83.6 68.17,82.62 68.03,82.47 66.04,82.47 66.04,82.48 65.84,82.48 65.51,82.15 64.78,82.15 64.67,82.26 60.74,82.26 60.53,82.47 57.01,82.47 56.87,82.33 54.52,79.98 48.11,79.98 46.8,78.68 v1(39.27,78.68)
  BOTTOM w0.095: 49.82,52.23 49.19,52.87 47.79,52.87
  BOTTOM w0.121: v1(39.27,78.68) 39.27,70.53 44.79,65.01 44.79,55.87 47.79,52.87
AM335X_AIN4: length 71.9
  TOP w0.102: U2.C8 79.42,84.18 v2(79.38,84.18)
  TOP w0.121: v1(65.57,85.76) 65.57,85.64 65.18,85.25 57.44,85.25 56.68,86.02 55.84,86.02 55.03,85.2 53.43,85.2 52.94,85.7 46.05,85.7 43.94,83.58 43.94,83.51 v1(43.62,83.2)
  BOTTOM w0.121: J9.13 47.61,56.04 46.54,57.11 46.54,65.32 40.5,71.36 40.5,77.74 41.19,78.42 41.19,80.07 43.62,82.51 v1(43.62,83.2) ; v2(79.38,84.18) 78.99,84.18 78.6,83.79 75.79,83.79 74.33,85.25 71.67,85.25 71.29,85.63 66.27,85.63 66.14,85.76 v1(65.57,85.76)
AM335X_AIN5: length 77.7
  TOP w0.102: U2.B8 78.71,83.8 78.38,84.13 77.1,84.13
  TOP w0.121: v1(42.84,88.53) 43.28,88.53 43.47,88.34 58.55,88.34 59.22,87.67 64.21,87.67 v1(64.68,88.13) ; v1(72.43,85.76) 73.44,85.76 73.81,85.39 74.41,85.39 75.42,84.38 76.29,84.38 76.54,84.13 77.1,84.13
  BOTTOM w0.121: v1(64.68,88.13) 65.08,87.74 67.26,87.74 67.37,87.62 67.39,87.62 69.13,85.89 71.86,85.89 71.99,85.76 v1(72.43,85.76) ; v1(42.84,88.53) 42.84,83.04 40.4,80.61 40.4,78.45 40.02,78.07 40.02,77.95 40,77.94 40,70.79 45.86,64.93 45.86,56.25 47.33,54.77 J9.15
AM335X_AIN6: length 60.1
  TOP w0.095: 50.71,54.01 50.58,54.14 49.19,54.14
  TOP w0.102: 77.1,83.8 U2.A8
  TOP w0.121: 77.1,83.8 76.52,83.8 76.18,84.13 75.31,84.13 74.33,85.12 70.39,85.12 70.14,84.87 70.14,84.49 69.82,84.17 68.42,84.17 v1(68.11,83.86) ; 49.19,54.14 J9.17 ; v1(58.38,51.45) 52.39,51.45 51.73,52.11 51.73,53 50.71,54.01
  BOTTOM w0.121: v1(68.11,83.86) 67.61,83.36 67.61,75.08 67.86,74.84 67.86,74.46 67.6,74.2 67.03,74.2 65.96,73.12 65.96,72.42 65.19,71.65 65.19,69.89 61.67,66.37 61.67,61.6 61.68,61.6 61.68,59.64 61.67,59.63 61.67,59.13 58.38,55.84 v1(58.38,51.45)
AM335X_AIN7: length 210.2
  TOP w0.102: v2(79.4,85) U2.C9
  TOP w0.121: R571.2 v1(129.45,160.13) 129.48,160.13 R23.1 ; v1(42.38,85.76) 42.38,86.2 44.27,88.09 57.97,88.09 59.03,87.03 64.2,87.03 65.19,88.02 65.19,88.3 65.19,88.31 65.19,88.94 65.46,89.21 65.63,89.21 65.86,89.44 65.87,89.44 66.12,89.7 66.54,89.7 66.67,89.57 67.01,89.57 67.14,89.7 67.56,89.7 67.85,89.4 67.85,87.04 68.49,86.4 71.67,86.4 71.68,86.41 71.68,86.41 72.05,86.78 74.52,86.78 74.65,86.65 75.48,86.65 75.81,86.32 v1(75.81,85.32) ; v1(118.2,153.99) 116.93,152.72 111.72,152.72 109.79,150.79 95.72,150.79 95.25,151.26 v1(83.46,151.26)
  LY3 w0.133: v1(129.45,160.13) 123.3,153.99 v1(118.2,153.99)
  LY4 w0.102: 77.1,87.67 77.1,87.3 v2(79.4,85)
  LY4 w0.133: v1(83.46,151.26) 82.32,150.11 82.32,145.52 82.49,145.35 82.49,135.93 80.89,134.33 80.89,121.27 73.16,113.55 73.16,103.39 73,103.22 73,101.7 72.74,101.44 72.74,101.07 73.16,100.65 73.16,93.2 74.51,91.86 74.51,90.26 77.1,87.67
  BOTTOM w0.102: 77.84,84.95 77.84,84.96 78.61,84.96 78.67,85.03 79.01,85.03 79.03,85 v2(79.4,85)
  BOTTOM w0.121: v1(75.81,85.32) 76.17,84.95 77.84,84.95 ; J9.19 47.7,52.23 44.36,55.58 44.36,64.88 38.83,70.41 38.83,79.52 42.38,83.07 v1(42.38,85.76)
AM335X_ECAP0_IN_PWM0_OUT: length 46.3
  TOP w0.121: v1(75.92,133.16) 75.53,132.77 73.81,132.77 R210.1 ; v1(79.89,97.01) 79.89,96.91 80.49,96.31 80.49,95.04 80.24,94.79 80.24,92.24 U2.C18
  BOTTOM w0.121: v1(79.89,97.01) 79.89,97.14 79.74,97.28 79.74,102.96 79.08,103.62 79.08,105.28 79.08,105.64 79.02,105.71 79.02,106.42 79.02,106.89 78.39,107.51 78.39,120.03 76.42,122 76.42,123.53 75.81,124.14 75.81,128.91 75.73,128.99 75.73,132.96 v1(75.92,133.16)
AM335X_EXT_WAKEUP: length 213.3
  TOP w0.102: 77.1,80.56 77.6,80.56 77.89,80.27 78.34,80.27 78.53,80.46 78.53,80.6 78.93,81 79.4,81 U2.C5
  TOP w0.121: R405.2 34.17,62.42 34.17,62.89 34.53,63.24 34.67,63.24 35.16,63.73 36.01,63.73 41.1,68.82 61.84,68.82 v1(62.29,68.36) ; v1(75.63,144.69) 74.36,145.96 67.08,145.96 v1(65.94,147.1) ; 77.1,80.56 76.36,80.56 75.48,79.67 71.79,79.67 71.4,79.28 71.05,79.28 70.68,78.91 68.9,78.91 68.68,78.68 68.68,78.59 68.54,78.46 68.54,75.48 67.75,74.69 v1(67.17,74.69)
  LY4 w0.133: v1(62.29,68.36) 62.29,66.43 64.11,64.61 64.11,55.46 68.74,50.84 73.7,50.84 74.21,50.33 75.18,50.33 78.02,47.5 78.02,40.8 78.78,40.04 v1(78.78,29.5)
  BOTTOM w0.121: R67.2 83.57,33.57 80.74,30.74 79,30.74 78.52,30.26 78.52,29.76 v1(78.78,29.5) ; R207.2 76.11,144.21 v1(75.63,144.69) ; v1(62.29,68.36) 63.38,69.46 63.38,70.51 65.7,72.82 65.7,73.21 v1(67.17,74.69) 67.17,78.07 64.81,80.43 64.81,82.08 64.43,82.46 64.43,83.63 63.72,84.33 63.72,87.35 63.03,88.05 63.03,92.62 63.09,92.68 63.09,97.76 63.41,98.08 64.05,98.08 64.55,98.59 64.55,101.35 64.19,101.71 64.19,102.07 64.96,102.85 64.96,103.11 65.54,103.69 65.54,104.18 64.68,105.04 64.68,111.8 59.85,116.62 59.85,120.56 58.39,122.02 58.39,129.64 57.95,130.09 57.95,134.91 57.31,135.55 57.31,140.37 57.7,140.75 59.47,140.75 61.76,143.04 61.76,145.2 63.66,147.1 v1(65.94,147.1)
AM335X_EXTINTN: length 131.8
  TOP w0.102: 79.72,92.9 79.72,92.65 79,91.93 U2.B18
  TOP w0.121: R479.2 34.81,62.8 v1(34.71,62.8) ; 79.72,92.9 79.72,93.99 79.07,94.64 77.57,94.64 76.63,95.58 73.59,95.58 73.06,95.05 72.45,95.05 72.04,95.05 71.34,95.75 70.94,95.75 69.58,97.1 66.27,97.1 65.41,97.1 64.81,96.5 61.96,96.5 61.86,96.4 R324.2 61.35,95.9 61.25,95.8 59.93,95.8 59.65,95.52 57.73,95.52 55.81,93.6 48.01,93.6 47.09,92.69 39.54,92.69 38.52,93.71 34.92,93.71 34.73,93.52 v1(34.73,93.08) ; v1(9.14,62.1) 9.14,55.69 9.12,55.67 9.12,55.3 9.14,55.28 9.14,52.41 9.22,52.34 9.22,51.97 9.14,51.9 9.14,51.43 8.42,50.71 8.34,50.71 8.04,50.41 8.04,50.33 v1(6.9,49.19)
  LY3 w0.133: v1(34.71,62.8) 34.01,62.1 v1(9.14,62.1)
  BOTTOM w0.121: v1(34.73,93.08) 35.3,92.51 35.3,88.3 28.78,81.78 28.78,67.23 32.22,63.79 33.72,63.79 v1(34.71,62.8) ; 6.9,47.28 v1(6.9,49.19)
AM335X_GMII1_COL: length 16.5
  TOP w0.102: v2(83.4,90.6) U2.H16
  TOP w0.121: R231.2 82.13,102.04 82.13,102.1 v1(82.46,102.42)
  LY4 w0.102: v2(83.4,90.6) 83.61,90.81 83.61,92.9
  LY4 w0.121: 83.6,101.76 83.12,101.76 v1(82.46,102.42)
  LY4 w0.133: 83.61,92.9 83.61,93.64 83.27,93.98 83.27,97.62 83.69,98.05 83.69,100.02 84.03,100.37 84.59,100.37 84.94,100.71 84.94,101.31 84.94,101.32 84.94,101.32 84.49,101.76 83.6,101.76
AM335X_GMII1_CRS: length 77
  TOP w0.102: U2.H17 83.8,91.03 83.47,91.36 83.47,92.83 83.54,92.9
  TOP w0.121: 83.54,92.9 83.54,94.61 83.46,94.7 83.46,96.18 82.91,96.72 82.91,98.34 82.38,98.86 v1(82.38,99.55) ; R316.2 53.25,133.09 53.56,132.78 53.56,132.67 54.65,131.58 54.65,130.38 55.7,129.34 60.47,129.34 60.82,129.69 65.65,129.69 66.01,129.33 66.67,129.33 76.37,129.33 76.44,129.26 76.8,129.26 76.86,129.33 81.73,129.33 83.58,131.18 v1(84.09,131.18)
  BOTTOM w0.121: v1(82.38,99.55) 81.98,99.96 81.98,100.93 81.71,101.2 81.71,106.07 81.63,106.14 81,106.77 81,118.59 82.26,119.85 82.26,120.36 83.8,121.9 83.8,130.89 v1(84.09,131.18)
AM335X_GMII1_MDIO_CLK: length 10.8
  TOP w0.102: U2.M18 v2(87,92.56)
  TOP w0.121: v1(90.4,95.54) 90.59,95.73 90.59,96.94 R433.2
  LY4 w0.102: 86.66,92.9 v2(87,92.56)
  LY4 w0.121: 86.66,93.61 86.66,92.9 ; v1(90.4,95.54) 90.07,95.86
  LY4 w0.133: 86.66,93.61 86.66,94.33 87.18,94.86 87.18,96.07 87.82,96.71 89.23,96.71 90.07,95.86
AM335X_GMII1_MDIO_DATA: length 13.8
  TOP w0.102: U2.M17 87.38,91.38 87.38,92.87 87.35,92.9
  TOP w0.121: 87.35,92.9 87.35,93.64 v1(87.16,93.83) ; R434.2 93.51,99.86 v1(93.64,99.99)
  LY3 w0.133: v1(87.16,93.83) 87.66,93.83 89.31,95.48 89.31,97.05 90.53,98.27 91.03,98.27 91.99,99.22 92.87,99.22 v1(93.64,99.99)
AM335X_GMII1_REFCLK: length 54.3
  TOP w0.102: 83.79,92.9 83.8,92.89 U2.H18
  TOP w0.121: 83.79,92.9 83.79,93.25 83.8,93.26 83.8,94.73 83.7,94.83 83.7,96.28 83.16,96.83 83.16,100.09 83.6,100.54 83.6,104.05 83.73,104.18 83.73,107.74 82.59,108.88 v1(82.21,108.88) R432.2 ; v1(85.71,129.77) 88.24,129.77 89.9,131.43 93.81,131.43 v1(93.94,131.3)
  BOTTOM w0.121: v1(85.71,129.77) 86.2,129.28 86.2,124.55 85.23,123.58 85.23,122.11 83.83,120.71 83.83,118.8 83.08,118.06 83.08,115.48 81.76,114.16 81.76,109.32 v1(82.21,108.88) ; R410.1 93.39,133.39 93.39,131.86 v1(93.94,131.3)
AM335X_GMII1_RXCLK: length 142.9
  TOP w0.102: 86.2,92.9 U2.L18
  TOP w0.121: v1(42.05,58.94) 42.05,58.09 R423.2 ; 86.2,92.9 86.2,94.04 85.76,94.47 85.76,94.73 85.76,96.13 86.85,97.22 86.85,100.21 86.48,100.59 86.48,102.56 85.86,103.18 v1(85.86,103.67) ; v1(86.27,115.56) 85.6,115.56 85.49,115.45 83.27,115.45 82.74,114.91 60.23,114.91 59.73,114.42 57.24,114.42 56.96,114.69 52.75,114.69 52.52,114.92 52.26,114.92 52.04,114.69 v1(50.1,114.69)
  BOTTOM w0.121: v1(85.86,103.67) 85.86,115.2 85.64,115.42 85.64,119.93 85.77,120.05 86.32,120.05 86.45,119.93 86.45,116.85 86.32,116.72 86.08,116.72 85.96,116.6 85.96,115.87 v1(86.27,115.56) ; v1(42.05,58.94) 42.46,59.35 42.46,64.05 42.31,64.19 42.31,64.48 42.3,64.49 42.3,64.69 37.34,69.65 37.31,69.65 37.31,80.15 40.48,83.32 40.48,84.52 40.77,84.82 40.77,84.95 40.77,94.65 41.46,95.34 41.46,97.93 43.04,99.51 43.04,107.88 45.08,109.92 45.08,110.09 44.42,110.75 44.42,110.92 44.59,111.09 44.76,111.09 45.42,110.43 45.59,110.43 45.76,110.6 45.76,110.77 45.11,111.43 45.11,111.6 45.28,111.77 45.45,111.77 46.1,111.12 46.27,111.12 46.45,111.29 46.45,111.46 45.79,112.11 45.79,112.29 45.96,112.46 46.13,112.46 46.79,111.8 46.96,111.8 47.79,112.63 48.62,112.63 50.1,114.11 v1(50.1,114.69)
AM335X_GMII1_RXD0: length 143.3
  TOP w0.102: v2(87.4,90.6) U2.M16
  TOP w0.121: v1(49.14,114.49) 49.14,114.05 49.4,113.79 50.49,113.79 50.7,114 56.71,114 56.96,113.75 60.79,113.75 61.28,114.24 83.63,114.24 83.83,114.03 87.11,114.03 87.23,114.15 87.23,115.05 87.35,115.18 87.59,115.18 87.71,115.05 87.71,114.15 87.83,114.03 88.07,114.03 88.2,114.15 88.2,115.51 88.32,115.63 88.55,115.63 88.68,115.51 88.68,114.15 88.8,114.03 88.91,114.03 89.67,113.27 90.63,113.27 v1(91.41,112.49) ; R424.2 v1(41.49,56.15)
  BOTTOM w0.102: 87.87,92.9 87.87,91.73 87.4,91.26 v2(87.4,90.6)
  BOTTOM w0.121: v1(49.14,114.49) 49.14,114.49 48.2,113.55 43.98,113.55 42.7,112.28 42.7,110.18 41.88,109.35 41.88,100.97 41.88,99.91 39.94,97.97 39.69,97.71 39.67,97.7 39.67,85.4 39.09,84.81 39.09,84.09 39.09,83.49 36.21,80.61 36.21,69 40.92,64.28 40.92,59.76 40.65,59.49 40.65,57.1 41.18,56.57 41.18,56.46 v1(41.49,56.15) ; 87.87,92.9 87.87,94.35 89.75,96.22 89.75,96.25 90.84,97.34 90.84,99.86 91.27,100.29 91.27,101.66 92.49,102.88 92.49,108.11 91.41,109.2 v1(91.41,112.49)
AM335X_GMII1_RXD1: length 143.5
  TOP w0.102: v2(86.6,89.8) U2.L15
  TOP w0.121: v1(48.6,110.66) 50.33,110.66 50.79,111.12 65,111.12 65.2,111.32 79.65,111.32 80.06,110.91 86.9,110.91 87.08,111.1 87.87,111.1 87.94,111.16 v1(88,111.16) ; v1(42.81,54.57) 42.81,54.51 42.56,54.27 R425.2
  BOTTOM w0.102: v2(86.6,89.8) 86.6,89.88 86.3,90.18 85.64,90.18 85.33,90.49 85.33,91.48 85.94,92.09 85.94,92.9
  BOTTOM w0.121: 85.94,92.9 85.94,93.56 86.33,93.95 86.33,94.07 87.17,94.92 87.17,95.85 87.25,95.93 87.25,98.85 87.9,99.5 87.9,106.31 88.68,107.1 88.68,109.46 88.56,109.59 88.3,109.59 88.18,109.71 88.18,110.5 88,110.68 v1(88,111.16) ; v1(42.81,54.57) 42.81,55.18 43.42,55.79 43.42,64.62 37.98,70.06 37.98,79.87 41.45,83.34 41.45,94.27 42.4,95.23 42.4,97.93 43.71,99.23 43.71,107.6 43.88,107.77 44.05,107.77 44.83,107 45,107 45.17,107.17 45.17,107.34 44.4,108.12 44.4,108.29 44.57,108.46 44.74,108.46 45.51,107.68 45.68,107.68 45.85,107.85 45.85,108.02 45.08,108.8 45.08,108.97 45.25,109.14 45.42,109.14 46.19,108.37 46.36,108.37 46.53,108.54 46.53,108.71 45.76,109.48 45.76,109.65 45.93,109.82 46.1,109.82 46.88,109.05 47.05,109.05 47.22,109.22 47.22,109.39 46.44,110.16 46.44,110.33 46.61,110.5 46.79,110.5 47.56,109.73 47.73,109.73 47.9,109.9 47.9,110.07 47.13,110.85 47.13,111.02 47.98,111.87 48.47,111.87 48.93,111.42 48.93,111.06 48.91,111.04 48.91,110.98 v1(48.6,110.66)
AM335X_GMII1_RXD2: length 143.2
  TOP w0.102: v2(86.6,90.6) U2.L16
  TOP w0.121: v1(49.39,110.22) 50.49,110.22 50.96,110.7 65.18,110.7 65.38,110.9 79.47,110.9 79.72,110.65 79.92,110.44 92.28,110.44 v1(93.38,111.54) ; v1(42.81,53) R427.2
  BOTTOM w0.102: v2(86.6,90.6) 87.02,90.18 87.64,90.18 87.79,90.33 87.79,90.43 87.79,91.1 88.35,91.65 88.35,92.9
  BOTTOM w0.121: v1(42.81,53) 43.88,55.05 43.88,63.26 43.88,64.76 38.4,70.24 38.4,79.7 41.87,83.16 41.87,83.52 41.87,94.02 43.04,95.18 43.04,97.96 43.8,98.72 44.13,99.06 44.13,105.09 47.16,108.11 50.59,108.11 50.72,108.24 50.72,112 50.59,112.13 49.52,112.13 49.39,112 v1(49.39,110.22) ; 88.35,92.9 88.35,94.23 90.17,96.04 90.18,96.04 92.16,98.03 92.16,101.15 v1(92.9,101.89) 93.51,102.5 93.51,111.42 v1(93.38,111.54)
AM335X_GMII1_RXD3: length 142.8
  TOP w0.102: 86.63,92.9 86.63,92.71 86.59,92.67 86.59,91.41 86.2,91.03 U2.L17
  TOP w0.121: v1(41.52,52.34) R428.2 ; 86.63,92.9 86.63,93.86 86.63,94.21 86.45,94.39 86.45,94.58 86.19,94.84 86.19,94.91 86.19,95.89 v1(86.81,96.51) ; v1(43.45,115.68) 44.7,116.93 64.27,116.93 65.19,116.01 81.11,116.01 81.73,116.63 86.78,116.63 86.8,116.62 v1(88.15,116.62)
  BOTTOM w0.121: v1(43.45,115.68) 43.45,114.16 42.28,112.99 42.28,110.35 41.46,109.53 41.46,100.8 41.46,100.09 39.77,98.4 39.38,98.01 39.25,97.88 39.25,85.58 38.66,84.99 38.66,83.92 38.66,83.66 35.78,80.78 35.78,68.79 40.5,64.07 40.5,59.93 40.23,59.66 40.23,53.62 v1(41.52,52.34) ; v1(88.15,116.62) 88.15,115.78 87.86,115.49 87.86,112.48 87.45,112.08 87.45,110.24 87.69,110 87.69,107.7 87.45,107.46 87.45,99.7 86.81,99.05 v1(86.81,96.51)

# Allegro board AM335x_GPEVM_ZCZBASEBOARD_3H0002_REV1_5A_PCB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A10: length 61
  TOP w0.102: U2.F4 v2(81.8,80.2)
  TOP w0.121: U33.H7 v1(92.98,59.04) ; U34.H7 v1(78.38,59.04)
  LY4 w0.076: 87.29,58 87.54,58 87.69,58.15 93.15,58.15 93.24,58.24
  LY4 w0.133: 93.24,58.24 93.24,58.77 v1(92.98,59.04) ; v1(78.38,59.04) 78.38,59.74 78.52,59.89 81.77,59.89 82.03,59.63 82.03,58.74 82.28,58.48 84.63,58.48 84.64,58.47 85.11,58.47 85.58,58 87.29,58
  BOTTOM w0.076: 93.68,55.54 93.66,55.56 93.66,56.71 93.3,57.07 92.83,57.07 92.61,57.28 92.61,58.67 v1(92.98,59.04)
  BOTTOM w0.121: 93.68,55.54 93.91,55.31 95.14,55.31 95.26,55.18 95.26,54.88 R614.2 ; v2(81.8,80.2) 81.8,80.2 82.21,79.79 82.21,79.09 80.51,77.4 80.46,77.4 79.7,76.65 79.7,74.55 79.83,74.42 79.92,74.42 80.05,74.3 80.05,69.8 79.88,69.64 79.88,69.37 79.69,69.18 79.69,67.7 80.2,67.19 82.31,67.19 82.4,67.28 82.77,67.28 83,67.05 83.88,67.05 84.01,67.18 84.01,67.3 84.14,67.42 86.09,67.42 86.22,67.3 86.22,66.13 86.09,66 84.8,66 84.54,65.75 84.54,63.46 84.24,63.16 83.35,63.16 80.48,60.29 79.89,60.29 79.01,59.4 78.75,59.4 v1(78.38,59.04)
DDR_A11: length 60.8
  TOP w0.121: v1(74.38,59.04) U34.M7 ; v1(88.98,59.04) U33.M7 ; v1(82.51,72.05) 82.51,72.49 82.38,72.61 82.38,77.43 82.58,77.63 82.58,78.61 82.43,78.75 82.43,78.77 U2.F2
  LY4 w0.076: v1(88.98,59.04) 88.84,58.89 87.82,58.89 87.62,59.09 87.29,59.09
  LY4 w0.127: v1(74.38,59.04) 74.1,59.31
  LY4 w0.133: 87.29,59.09 86,59.09 85.56,59.52 83.32,59.52 83.2,59.65 83.2,60.69 83.07,60.81 77.15,60.81 77.02,60.69 77.02,60.21 76.9,60.08 74.23,60.08 74.1,59.96 74.1,59.31 ; v1(82.51,72.05) 82.51,71.43 82.05,70.98 79.74,70.98 79.1,70.33 79.1,70.32 77.5,68.72 76.44,68.72 75.81,68.08 75.5,68.08 74.88,68.71 73.12,68.71 73.12,68.7 72.74,68.7 72.5,68.46 v1(72.5,67.5)
  BOTTOM w0.121: R615.2 86.24,55.26 86.24,57.62 87.31,58.69 87.31,58.81 87.44,58.94 88.5,58.94 88.59,59.04 v1(88.98,59.04) ; v1(72.5,67.5) 70.88,65.88 69.77,65.88 69.2,65.31 69.2,62.18 71.14,60.24 73.95,60.24 74.38,59.81 v1(74.38,59.04)
DDR_A12: length 61.6
  TOP w0.102: v2(81,79.4) U2.E3
  TOP w0.121: v1(90.58,59.04) U33.K7 ; v1(75.98,59.04) U34.K7
  LY4 w0.076: v1(90.58,59.04) 90.95,59.04 91.02,58.97 91.02,58.62 90.89,58.49 87.58,58.49 87.51,58.56 87.29,58.56
  LY4 w0.133: 87.29,58.56 87.2,58.56 87.2,58.56 85.78,58.56 85.36,58.99 82.79,58.99 82.66,59.12 82.66,60.03 82.34,60.36 77.76,60.36 77.63,60.23 77.63,59.65 77.51,59.52 76.47,59.52 76.26,59.31 v1(75.98,59.04)
  BOTTOM w0.121: R616.2 87.21,54.98 87.21,57.72 87.9,58.41 89.95,58.41 v1(90.58,59.04) ; v1(75.98,59.04) 75.7,59.31 75.7,59.66 74.31,61.04 74.21,61.04 73.98,61.27 73.98,62.54 73.77,62.75 71.08,62.75 70,63.83 70,64.86 70.26,65.12 70.76,65.12 70.89,65 70.89,64.78 71.02,64.65 72.59,64.65 72.71,64.78 72.71,66.49 73.02,66.79 74.26,66.79 74.73,67.27 74.73,68.45 75.16,68.87 75.16,68.88 75.61,69.33 76.7,69.33 77.09,68.94 77.46,68.94 77.78,69.26 77.78,69.51 77.46,69.83 77.46,70.33 79.14,72 79.14,73.14 78.29,73.98 78.29,76.39 81,79.1 v2(81,79.4)
DDR_A13: length 61
  TOP w0.102: U2.H3 v2(83.4,79.4)
  TOP w0.121: v1(88.18,62.24) U33.N3 ; v1(73.58,61.44) U34.N3
  LY4 w0.076: 75.98,64.12 75.55,63.68 75.55,63.68 74.47,62.6 74.22,62.6 73.95,62.32 73.95,61.8 v1(73.58,61.44) ; 87.54,63.66 87.81,63.39 87.81,62.6 v1(88.18,62.24)
  LY4 w0.133: 75.98,64.12 76.27,64.41 76.3,64.41 76.39,64.5 78.14,64.5 79.2,65.56 85.64,65.56 87.54,63.66 ; v1(73.58,61.44) 73.12,61.89 73.12,64 73.8,64.68 73.98,64.68 74.99,65.7 76.87,65.7 78.27,67.09 79.23,67.09 79.51,67.37 79.51,67.92 80.03,68.44 v1(80.48,68.44)
  BOTTOM w0.076: v1(88.18,62.24) 88.61,62.66 88.61,64.02
  BOTTOM w0.121: v1(80.48,68.44) 80.95,68.91 81.51,68.91 81.64,69.04 81.64,69.53 81.77,69.66 82.52,69.66 82.65,69.53 82.65,68.82 82.78,68.69 85.94,68.69 86.07,68.82 86.07,69.35 83.79,71.63 83.79,71.74 83,72.53 82.54,72.53 82.41,72.66 82.41,74.87 82.28,74.99 81.03,74.99 80.9,75.12 80.9,75.34 80.9,75.34 80.9,75.71 80.9,75.71 80.9,75.72 81.49,76.31 81.49,77 83.4,78.9 v2(83.4,79.4) ; 88.61,64.02 88.34,64.29 87.96,64.29 87.57,64.68 87.29,64.68 87.03,64.93 87.03,65.55 87.37,65.89 87.37,65.91 87.67,66.2 R617.2
DDR_A14: length 61.6
  TOP w0.102: v2(83.4,80.2) U2.H4
  TOP w0.121: v1(78.07,72.45) 79.29,72.45 81.01,74.18 81.01,75.2 v1(81.34,75.53) ; v1(73.58,59.04) U34.N7 ; v1(88.05,59.35) 88.31,59.09 88.31,58.9 U33.N7
  LY4 w0.076: 87.42,59.35 87.29,59.35
  LY4 w0.127: v1(88.05,59.35) 87.42,59.35 ; 73.3,59.31 v1(73.58,59.04)
  LY4 w0.133: 87.29,59.35 86.11,59.35 85.65,59.8 83.58,59.8 83.45,59.93 83.45,60.91 83.34,61.02 76.88,61.02 76.77,60.91 76.77,60.62 76.74,60.58 76.74,60.58 76.5,60.35 76.03,60.35 75.91,60.46 73.43,60.46 73.3,60.34 73.3,59.31
  BOTTOM w0.121: v1(88.05,59.35) 87.54,59.35 85.97,57.77 85.97,55.33 85.84,55.21 84.62,55.21 84.49,55.08 R618.2 ; v2(83.4,80.2) 83.4,80.19 83.79,79.79 83.79,79.56 83.79,79.06 83.7,78.97 83.7,78.56 82.05,76.91 82.05,76.24 v1(81.34,75.53)
  BOTTOM w0.127: v1(78.07,72.45) 76.41,70.8 75.44,70.8 74.28,69.64 74.28,69.47 73.26,68.45 71.09,68.45 70.27,67.63 69.94,67.63 67.91,65.59 67.91,62.6 71.44,59.07 71.84,59.07 71.87,59.04 v1(73.58,59.04)
DDR_A15: length 62.1
  TOP w0.102: v2(80.2,79.4) U2.D3
  TOP w0.121: v1(91.38,59.04) U33.J7 ; v1(68.46,63.23) 69.63,63.23 73.18,59.68 76.14,59.68 v1(76.78,59.04) U34.J7
  LY4 w0.076: 87.29,58.3 87.29,58.3 87.62,58.3 87.62,58.31 91.76,58.31 91.88,58.44
  LY4 w0.133: v1(91.38,59.04) 91.76,59.04 91.88,58.91 91.88,58.44 ; 87.29,58.3 85.68,58.3 85.25,58.73 82.64,58.73 82.38,58.99 82.38,59.7 81.95,60.14 78.04,60.14 77.91,60.01 77.91,59.16 77.79,59.04 v1(76.78,59.04)
  BOTTOM w0.121: v1(68.46,63.23) 68.46,65.72 69.99,67.25 70.4,67.25 71.35,68.2 73.37,68.2 75.35,70.18 76.48,70.18 78.63,72.33 78.63,72.83 78.5,72.96 78.06,72.96 77.68,73.34 77.68,76.72 79.59,78.62 79.72,78.62 80.2,79.11 v2(80.2,79.4) ; R619.2 87.59,55.61 87.59,57.42 88.35,58.17 90.19,58.17 90.21,58.2 90.23,58.2 90.46,58.43 90.78,58.43 v1(91.38,59.04)
DDR_BA0: length 62.5
  TOP w0.102: U2.C4 v1(79.4,80.2)
  TOP w0.121: R620.2 94.4,65.7 94.4,65.26 94.27,65.14 v1(93.51,65.14) ; U33.J2 v1(91.38,62.24) ; v1(72.94,69.15) 72.94,68.56 73.37,68.13 73.37,66.86 74.85,65.38 77.16,65.38 77.61,64.93 77.61,63.07 U34.J2 v1(76.78,62.24)
  LY4 w0.076: 87.4,60.95 87.42,60.92 90.6,60.92 90.79,61.11 90.84,61.11 90.97,61.24 90.97,61.68 90.84,61.81 90.84,62.11 90.97,62.24 v1(91.38,62.24) 91.38,63.06 91.93,63.61 91.93,64.02 92.49,64.58 ; v1(76.78,62.24) 77.19,62.65 77.24,62.65 77.54,62.95 79.13,62.95 79.92,63.74 80.17,63.74 80.22,63.69 80.22,63.38 80.38,63.23 84.53,63.23
  LY4 w0.127: 84.53,63.23 84.54,63.24 84.59,63.24
  LY4 w0.133: 92.49,64.58 93.51,64.58 93.6,64.67 94.02,64.67 94.14,64.8 94.14,65.01 94.02,65.14 v1(93.51,65.14) ; 87.4,60.95 86.95,60.95 86.32,61.58 85.69,61.58 85.3,61.96 85.3,62.84 84.85,63.29 84.63,63.29 84.59,63.24
  BOTTOM w0.121: v1(72.94,69.15) 72.94,73.04 72.81,73.17 71.82,73.17 71.69,73.3 71.69,73.55 71.82,73.68 72.81,73.68 72.94,73.8 72.94,74.06 72.81,74.19 71.54,74.19 71.41,74.31 71.41,74.57 71.54,74.69 72.81,74.69 72.94,74.82 72.94,75.42 73.15,75.64 73.15,75.82 72.4,76.57 72.4,76.75 72.58,76.93 72.76,76.93 73.51,76.18 73.69,76.18 73.87,76.36 73.87,76.54 73.08,77.32 73.08,77.5 73.26,77.68 73.44,77.68 74.23,76.9 74.41,76.9 75.9,78.39 75.9,79.29 76.46,79.85 78.5,79.85 78.85,80.2 v1(79.4,80.2)
DDR_BA1: length 60.9
  TOP w0.121: v1(75.98,57.44) U34.K8 ; v1(75.6,68.69) 75.6,69.14 76.28,69.81 76.28,70.29 76.4,70.42 80.73,70.42 80.86,70.55 80.86,70.75 80.73,70.88 76.92,70.88 76.8,71 76.8,71.16 76.92,71.28 77.35,71.28 77.61,71.54 77.61,72.77 77.74,72.9 78.89,72.9 80.71,74.71 80.71,75.52 81.16,75.97 81.16,75.98 81.4,76.22 U2.E1 ; v1(90.58,57.44) U33.K8
  LY4 w0.133: v1(75.98,57.44) 76.38,57.03 78.62,57.03 80.07,55.59 82.05,55.59 82.49,55.16 90.61,55.16 90.98,55.52 90.98,56.47 90.98,56.47 90.98,57.04 v1(90.58,57.44)
  BOTTOM w0.076: 91.07,55.54 91.03,55.58 91.03,56.46 91.01,56.48 91.01,57.28 91.01,57.9 90.89,58.03 90.28,58.03 90.16,57.9 90.16,57.49 90.21,57.44 v1(90.58,57.44)
  BOTTOM w0.121: v1(75.6,68.69) 75.07,68.16 75.07,66.61 76.64,65.04 76.64,64.65 76.08,64.1 76.08,62.9 75.58,62.4 75.58,62.08 75.34,61.84 75.3,61.84 75.3,61.84 75.06,61.84 75.05,61.83 75.01,61.83 74.78,61.6 74.78,61.59 74.77,61.58 74.77,61.09 76.36,59.5 76.36,59.2 76.37,59.2 76.37,58.87 76.37,58.87 76.37,57.83 v1(75.98,57.44) ; R621.2 92.87,55.03 92.67,55.23 91.38,55.23 91.07,55.54
DDR_BA2: length 61.1
  TOP w0.121: v1(91.38,61.44) U33.J3 ; v1(93.76,64.27) 94.91,65.42 R622.2 ; U34.J3 v1(76.78,61.44) 76.78,60.41 76.62,60.26 73.57,60.26 68.18,65.65 68.18,72.1 68.43,72.35 71.36,72.35 71.61,72.6 71.61,75.5 73.16,77.05 74.15,77.05 74.61,77.51 75.69,77.51 78.1,77.51 78.59,77.99 78.59,79.11 79,79.52 U2.B3
  LY4 w0.076: 84.62,63.03 79.49,63.03 79.23,62.78 77.6,62.78 77.15,62.33 77.15,61.81 ; 87.29,60.69 90.47,60.69 90.79,60.37 91.35,60.37 91.48,60.5 91.48,60.97 91.38,61.07 v1(91.38,61.44) 91.38,61.71 91.75,62.08 91.75,62.13 91.76,62.14 91.76,63.18 92.85,64.27 93.28,64.27
  LY4 w0.127: 84.75,63.03 84.62,63.03 ; 77.15,61.81 v1(76.78,61.44)
  LY4 w0.133: v1(93.76,64.27) 93.28,64.27 ; 84.75,63.03 84.97,62.8 84.97,61.92 85.58,61.32 86.21,61.32 86.84,60.69 87.29,60.69
DDR_CASN: length 61.2
  TOP w0.121: v1(78.38,61.44) U34.G3 ; U2.F1 82.2,77.76 82.13,77.69 82.13,75.14 82.06,75.08 82.06,72 81.94,71.87 79.74,71.87 79.62,71.74 79.62,71.51 79.74,71.39 82.63,71.39 82.76,71.26 82.76,70.19 82.63,70.06 81.9,70.06 81.77,69.94 81.77,69.51 81.9,69.38 82.52,69.38 82.65,69.25 82.65,68.5 82.57,68.42 82.57,67.87 82.45,67.74 79.82,67.74 79.69,67.87 79.69,68.57 79.56,68.69 79.17,68.69 79.04,68.57 v1(79.04,67.78) ; v1(92.98,61.44) U33.G3
  LY4 w0.076: 87.29,59.9 89.71,59.9 89.9,60.1 90.36,60.1 90.58,59.88 92.72,59.88
  LY4 w0.127: 81.19,61.83 79.81,61.83 79.42,61.44 v1(78.38,61.44)
  LY4 w0.133: 92.72,59.88 92.98,60.14 v1(92.98,61.44) ; 81.19,61.83 81.32,61.96 81.32,62.11 81.44,62.24 82.61,62.24 82.74,62.11 82.74,61.96 82.87,61.83 83.86,61.83 83.98,61.7 83.98,60.54 84.11,60.41 86.02,60.41 86.14,60.29 86.14,60.11 86.35,59.9 87.29,59.9
  BOTTOM w0.076: v1(92.98,61.44) 93.35,61.44 93.41,61.49 93.41,62.48 93.53,62.6 93.69,62.6 93.81,62.73 93.81,63.78 93.69,63.91 93.46,63.91 93.33,64.03 93.33,64.46 93.55,64.68 93.56,64.68
  BOTTOM w0.121: 93.56,64.68 93.57,64.7 93.69,64.7 93.95,64.95 93.95,65.32 93.69,65.58 93.5,65.58 R601.2 ; v1(79.04,67.78) 79.04,67.04 79.14,66.94 81.98,66.94 82.1,66.81 82.1,66.38 81.98,66.25 79.14,66.25 79.01,66.13 79.01,62.65 79,62.64 79,62.02 78.97,62 78.97,61.99 78.42,61.44 v1(78.38,61.44)
DDR_CKE: length 62.1
  TOP w0.102: U2.G3 v2(82.6,79.4)
  TOP w0.121: v1(72.35,58.43) 71.67,58.43 R635.2 ; U34.G9 v1(78.38,56.64) ; v1(92.98,56.64) 92.98,56.04 93.11,55.92 93.69,55.92 93.81,56.04 93.81,56.93 93.71,57.04 U33.G9
  LY4 w0.127: 74.74,67.45 76.16,67.45 76.82,68.11 78.04,68.11 79.39,69.46 79.63,69.46 79.63,69.45 v1(80.33,69.45)
  LY4 w0.133: v1(92.98,56.64) 92.7,56.36 91.21,54.87 82.22,54.87 81.8,55.28 79.73,55.28 v1(78.38,56.64) 77.62,56.64 77.22,56.24 74.21,56.24 73.97,56.48 73.97,56.8 73.74,57.04 73.41,57.04 73.18,57.27 73.18,57.27 72.35,58.1 v1(72.35,58.43) 72.35,65.06 74.74,67.45
  BOTTOM w0.076: 93.21,55.54 93.26,55.58 93.26,55.76 93.46,55.97 93.46,56.53 93.35,56.64 v1(92.98,56.64)
  BOTTOM w0.121: R631.1 78.65,55.29 78.65,56.36 v1(78.38,56.64) ; v2(82.6,79.4) 82.6,79.04 81.6,78.03 81.6,78.03 80.36,76.8 80.36,76.17 80.33,76.13 v1(80.33,69.45) ; 93.26,55.06 94.22,55.06 94.35,54.93 94.35,54.55 94.22,54.42 93.99,54.42 R598.2
  BOTTOM w0.127: 93.21,55.54 93.08,55.4 93.08,55.24 93.26,55.06
DDR_CLK: length 61
  TOP w0.076: 79.27,61.49 79.27,61.51 79.21,61.57 79.21,61.64 79.22,61.65 79.22,63.56 79.46,63.8 79.55,63.8 79.56,63.81
  TOP w0.095: U33.F7 94.2,58.64 94.58,59.02 v1(94.58,59.04) 94.79,59.25 94.86,59.25 95.19,59.57 98.9,59.57 99.03,59.45 99.03,59.37 99.15,59.24 99.68,59.24 99.81,59.37 99.81,59.39 99.94,59.52 100.07,59.52 R624.2 ; 79.27,61.49 79.27,61.05 79.77,60.55 79.77,59.24 v1(79.98,59.04) U34.F7 ; U2.D2 81.01,78.59 81.01,77.96 80.48,77.43 80.48,77.23 80.28,77.03 80.28,75.58 79.89,75.2 79.89,74.89 79.16,74.15 77.7,74.15 77.35,73.81 77.35,72.47 76.88,71.99 75.94,71.99 75.81,71.85 75.81,70.14 75.58,69.91 74.41,69.91 74.08,69.58 74.08,69.05 74.66,68.47 74.66,67.08 75.41,66.33 76.15,66.33 76.31,66.5 76.31,68.48 76.78,68.95 77.42,68.95 77.89,68.48 77.89,66.88 78.03,66.74 78.41,66.74 78.61,66.53 79.79,66.53 80.17,66.15 80.17,64.67 80.07,64.56 80.07,64.47 79.66,64.06 79.66,63.91 79.56,63.81
  LY4 w0.076: 93.92,57.83 93.39,57.83 93.39,57.83 88.01,57.83 87.78,57.61 87.78,57.58 87.45,57.25 87.45,57.06
  LY4 w0.102: 87.45,57.06 87.31,56.92 85.36,56.92 84.29,57.98 81.03,57.98 80.71,58.31 80.71,58.41 80.56,58.56 80.56,58.71 80.71,58.86 80.71,59.25 80.59,59.37 80.09,59.37 79.96,59.25 79.96,59.05 v1(79.98,59.04) ; 93.92,57.83 94.33,58.24 94.33,58.79 v1(94.58,59.04)
DDR_CLKN: length 61.2
  TOP w0.076: 78.99,61.49 78.99,61.51 79.06,61.57 79.06,61.7 79.07,61.71 79.07,63.62 79.35,63.9 79.35,63.99 79.36,64.01
  TOP w0.095: R625.2 100,60.11 99.69,59.8 99.2,59.8 99.13,59.87 95.07,59.87 95.06,59.87 95.06,59.85 94.74,59.53 94.27,59.53 v1(93.78,59.04) U33.G7 ; U34.G7 v1(79.18,59.04) 79.49,59.35 79.49,60.44 78.99,60.93 78.99,61.49 ; 79.36,64.01 79.38,64.03 79.38,64.18 79.79,64.59 79.79,64.68 79.89,64.78 79.89,66.04 79.68,66.25 78.49,66.25 78.29,66.46 77.91,66.46 77.61,66.76 77.61,68.36 77.3,68.67 76.9,68.67 76.59,68.36 76.59,66.38 76.26,66.05 75.3,66.05 74.38,66.97 74.38,68.35 73.8,68.93 73.8,69.7 74.29,70.19 75.42,70.19 75.53,70.29 75.53,71.97 75.82,72.27 76.76,72.27 77.08,72.58 77.08,73.93 77.58,74.43 79.04,74.43 79.61,75.01 79.61,75.31 79.97,75.67 79.97,76.14 79.84,76.26 79.69,76.26 79.56,76.39 79.56,76.96 79.75,77.15 79.97,77.15 80.2,77.38 80.2,77.54 80.6,77.95 U2.D1
  LY4 w0.076: 87.24,57.28 87.25,57.29 87.27,57.29 87.63,57.65 87.63,57.67 87.94,57.99 93.45,57.99 93.45,57.98 93.65,57.98 93.71,58.05
  LY4 w0.102: 93.71,58.05 94.03,58.37 94.03,58.79 v1(93.78,59.04) ; v1(79.18,59.04) 79.35,59.21 79.35,59.21 79.44,59.3 79.44,59.43 79.7,59.69 80.72,59.69 81.01,59.4 81.01,58.43 81.16,58.29 84.42,58.29 85.48,57.23 87.18,57.23 87.24,57.28
DDR_CSN0: length 62.3
  TOP w0.121: v1(84.45,69.75) 83.84,69.75 83.72,69.88 83.72,70.29 83.84,70.42 84.39,70.42 84.52,70.55 84.52,70.83 84.39,70.95 83.84,70.95 83.72,71.08 83.72,73.27 83.84,73.39 84.39,73.39 84.52,73.52 84.52,75.19 84.17,75.54 84.17,78.65 83.82,79 U2.H2 ; v1(73.95,67.6) 73.95,66.83 75.15,65.63 77.61,65.63 78.07,65.18 78.07,64.4 78.29,64.17 78.29,62.95 U34.H2 v1(77.58,62.24) ; U33.H2 v1(92.18,62.24)
  LY4 w0.076: v1(77.58,62.24) 77.95,62.6 78.53,62.6 78.84,62.29 79.29,62.29 79.41,62.42 79.41,62.65 79.54,62.78 84.57,62.78 ; 91.76,61.81 91.76,60.57 91.41,60.22 90.66,60.22 90.47,60.42 87.84,60.42 87.84,60.42 87.29,60.42
  LY4 w0.127: 86.75,60.42 86.75,60.42 87.13,60.42 ; 91.76,61.81 v1(92.18,62.24)
  LY4 w0.133: 84.57,62.78 84.7,62.65 84.7,61.84 85.47,61.06 86.11,61.06 86.73,60.43 86.74,60.43 86.75,60.42 87.29,60.42 ; v1(73.95,67.6) 74.41,68.06 75.07,68.06 75.32,67.8 76.14,67.8 76.75,68.41 77.68,68.41 79.79,70.52 81.47,70.52 82.59,69.4 83.43,69.4 83.88,69.86 83.88,70.85 84.01,70.98 84.57,70.98 84.77,70.78 84.77,70.07 v1(84.45,69.75)
  BOTTOM w0.076: v1(92.18,62.24) 91.81,61.86 90.79,61.86 90.66,61.99 90.66,62.6 90.95,62.88 90.95,63.99 90.66,64.27 90.66,64.55 90.79,64.68 90.91,64.68
  BOTTOM w0.121: R599.2 91.35,65.7 91.35,65.12
  BOTTOM w0.127: 90.91,64.68 91.35,65.12
DDR_D0: length 35.3
  TOP w0.102: v2(87.4,79.4) U2.M3
  TOP w0.121: U33.B3 v1(97.78,61.44)
  BOTTOM w0.121: v2(87.4,79.4) 87.4,77.34 87.72,77.02 87.72,75.11 88.16,74.66 89.92,74.66 91.43,73.16 91.43,69.48 91.68,69.23 94.64,69.23 94.87,69 94.87,67.47 95.12,67.22 95.64,67.22 95.9,67.47 95.9,68.92 96.15,69.18 96.5,69.18 96.96,68.71 96.96,67.07 96.71,66.81 95.85,66.81 95.59,66.56 95.59,66.17 95.85,65.91 97.12,65.91 97.25,65.78 97.38,65.78 99.73,63.44 99.73,62.24 98.93,61.44 v1(97.78,61.44)
DDR_D1: length 35.9
  TOP w0.102: v2(87.4,80.2) U2.M4
  TOP w0.121: v1(96.98,59.04) U33.C7 ; v1(91.92,71.11) 92.37,71.11 92.39,71.08 v1(94.25,71.08)
  BOTTOM w0.121: v2(87.4,80.2) 87.4,80.19 87.79,79.79 87.79,77.63 88.56,76.87 89.1,76.87 89.8,76.17 89.8,75.14 91.92,73.02 v1(91.92,71.11) ; v1(96.98,59.04) 97.47,59.52 100.65,59.52 101.36,60.24 101.36,64.43 100.19,65.59 99.63,65.59 98.56,66.66 98.56,70.45 97.93,71.08 v1(94.25,71.08)
DDR_D2: length 35.4
  TOP w0.121: U2.N1 87.8,77.27 88.19,76.87 89.11,76.87 89.9,76.08 90.11,76.08 95.41,70.78 95.44,70.78 95.9,70.32 96.63,70.32 98.69,68.26 98.69,65.24 98.94,64.98 99.66,64.98 99.91,65.24 99.91,68.97 100.16,69.23 100.72,69.23 100.98,68.97 100.98,63.23 100.72,62.98 96.93,62.98 U33.C2
DDR_D3: length 35.8
  TOP w0.121: v1(96.98,57.44) U33.C8
  TOP w0.127: v1(99.33,67.02) 99.33,68.15 96.7,70.78 95.81,70.78 90.09,76.51 89.84,76.51 89.22,77.13 89.21,77.13 89.09,77.25 88.76,77.25 88.26,77.75 88.26,78.05 88.26,78.06 88.26,78.54 U2.N2
  BOTTOM w0.127: v1(96.98,57.44) 96.98,57.83 97.41,58.25 98.58,58.25 99.57,57.26 100.7,57.26 101.21,57.77 101.54,57.77 102.09,58.33 102.09,66.46 101.53,67.02 v1(99.33,67.02)
DDR_D4: length 35.9
  TOP w0.102: U2.N3 v2(88.2,79.4)
  TOP w0.127: v1(95.38,61.44) 95.38,60.63 94.68,59.93 94.3,59.93 93.97,60.26 93.97,60.82 U33.E3
  BOTTOM w0.121: v1(95.38,61.44) 95.66,61.71 95.66,61.96 95.82,62.11 96.55,62.11 97.52,61.14 97.52,61.12 97.78,60.87 98.77,60.87 100.09,62.19 100.09,63.51 97.22,66.38 97.22,68.82 96.53,69.51 92.47,69.51 92.37,69.61 92.37,73.21 90.21,75.37 90.21,76.17 88.2,78.18 v2(88.2,79.4)
DDR_D5: length 35.8
  TOP w0.102: U2.N4 v2(88.2,80.2)
  TOP w0.121: v1(95.38,57.44) U33.E8
  BOTTOM w0.121: v1(95.38,57.44) 94.98,57.83 94.98,59.22 95.9,60.13 95.9,61 96.15,61.25 96.58,61.25 97.27,60.57 99.15,60.57 100.39,61.8 100.39,63.59 97.57,66.41 97.57,68.95 96.46,70.06 93.48,70.06 92.7,70.85 92.7,73.49 91.81,74.38 91.81,75.21 88.59,78.42 88.59,79.81 v2(88.2,80.2)
DDR_D6: length 35.3
  TOP w0.121: U33.D2 96.18,62.24 96.18,61.3 96.33,61.15 v1(96.33,60.78)
  TOP w0.305: U2.P3 v2(89,79.4)
  BOTTOM w0.121: v1(96.33,60.78) 96.87,60.24 100.16,60.24 100.7,60.77 100.7,63.69 100.03,64.36 97.9,66.48 97.9,66.58 97.89,66.59 97.89,69.59 97.17,70.32 93.79,70.32 92.98,71.13 92.98,72.43 93.26,72.71 94.07,72.71 94.3,72.94 94.3,73.87 93.92,74.26 92.52,74.26 92.11,74.66 92.11,75.48 89,78.59 v2(89,79.4)
DDR_D7: length 35.9
  TOP w0.102: U2.P4 v2(89,80.2)
  TOP w0.121: v1(95.38,59.04) U33.E7
  BOTTOM w0.121: v2(89,80.2) 89.39,79.81 89.39,78.64 90.78,77.25 90.78,77.24 92.54,75.48 92.54,75.2 93.22,74.52 94.08,74.52 94.68,73.93 94.68,72.73 94.32,72.38 93.92,72.38 93.38,71.84 93.38,71.26 94.07,70.57 97.49,70.57 98.14,69.92 98.14,66.7 101.05,63.79 101.05,60.54 100.44,59.93 96.28,59.93 v1(95.38,59.04)
DDR_D8: length 35.4
  TOP w0.121: U34.B3 82.78,62.17 82.45,62.5 82.45,62.77 82.78,63.1 83.98,63.1 84.37,63.49 84.37,64.3 84.24,64.43 81.24,64.43 81.11,64.55 81.11,64.71 81.24,64.83 83.58,64.83 83.7,64.96 83.7,65.14 83.58,65.26 81.19,65.26 81.06,65.39 81.06,67.32 81.19,67.45 81.88,67.45 82,67.32 82,66.48 82.13,66.36 83.58,66.36 83.7,66.48 83.7,69.18 83.83,69.31 84.92,69.31 85.05,69.43 85.05,71.16 84.92,71.28 84.11,71.28 83.98,71.41 83.98,71.79 84.11,71.92 84.9,71.92 85.03,72.05 85.03,72.38 84.9,72.5 84.14,72.5 84.01,72.63 84.01,72.99 84.14,73.11 84.77,73.11 84.9,73.24 84.9,75.3 84.54,75.65 84.54,77.58 84.6,77.64 U2.J1
DDR_D9: length 35.8
  TOP w0.121: U34.C7 81.98,59.07 82.13,59.22 83.91,59.22 83.98,59.14 84.8,59.14 84.92,59.02 84.92,57.09 85.05,56.96 86.65,56.96 86.78,57.09 86.78,59.67 86.91,59.79 87.08,59.79 87.21,59.92 87.21,65.09 86.93,65.37 86.93,66.77 87.42,67.26 87.42,68.14 88.22,68.93 88.24,68.93 89.7,70.4 v1(90.89,70.4)
  TOP w0.127: v1(87.32,72.66) 86.7,72.66 85.25,74.1 85.25,75.65 85.7,76.1 85.7,77.63 85.65,77.68 85.65,77.71 85.6,77.76 85.6,77.77 85.4,77.96 U2.K1
  BOTTOM w0.127: v1(87.32,72.66) 88.11,71.87 89.83,71.87 89.95,71.74 89.95,70.52 90.08,70.4 v1(90.89,70.4)
DDR_D10: length 35.4
  TOP w0.121: U34.C2 82.23,62.38 82.23,62.13 82.41,61.95 82.41,61.28 82.54,61.15 84.49,61.15 84.62,61.28 84.62,64.65 84.49,64.78 84.19,64.78 84.06,64.91 84.06,65.44 83.93,65.57 81.52,65.57 81.39,65.7 81.39,65.9 81.52,66.03 83.93,66.03 84.06,66.15 84.06,68.92 84.19,69.05 85.2,69.05 85.33,69.18 85.33,72.86 85.46,72.99 85.89,72.99 86.01,72.86 86.01,72.45 86.14,72.32 87.03,72.32 87.14,72.21 87.51,72.21 87.62,72.32 88.38,72.32 88.51,72.45 88.51,73.29 88.38,73.42 86.3,73.42 85.51,74.21 85.51,75.51 85.64,75.64 85.84,75.64 85.96,75.77 85.96,77.69 85.88,77.77 85.88,77.81 85.83,77.86 85.83,78.59 85.41,79 U2.K2
DDR_D11: length 35.7
  TOP w0.102: v2(85.8,79.4) U2.K3
  TOP w0.121: v1(89.77,69.48) 88.72,68.43 88.43,68.43 87.98,67.98 87.98,67 87.46,66.48 87.46,65.68 87.72,65.42 87.72,59.75 87.59,59.63 87.59,58.61 87.31,58.33 87.31,56.53 87.18,56.4 84.52,56.4 84.39,56.53 84.39,58.1 84.26,58.23 82.37,58.23 U34.C8
  BOTTOM w0.121: v1(89.77,69.48) 88.35,69.48 86.44,71.39 86.44,71.5 86.37,71.57 86.37,73.05 86.37,73.05 86.37,73.79 86.59,74 86.59,74.44 86.37,74.66 86.37,74.74 85.71,75.4 85.53,75.4 84.81,76.12 84.81,76.63 85.76,77.58 85.76,78.97 85.8,79.01 v2(85.8,79.4)
DDR_D12: length 35.8
  TOP w0.102: U2.K4 v2(85.8,80.2)
  TOP w0.121: v1(88.53,70.78) 88.53,70.33 88.31,70.1 88.29,70.1 88.08,70.1 86.01,68.03 86.01,68.02 85.89,67.91 85.89,67.04 86.09,66.84 86.09,60.06 86.02,59.98 86.02,59.98 85.89,59.85 85.69,59.85 85.56,59.98 84.64,59.98 84.59,59.93 80.5,59.93 80.38,60.06 U34.E3
  BOTTOM w0.121: v2(85.8,80.2) 85.86,80.2 86.21,79.86 86.21,79.56 86.21,77.68 85.95,77.43 85.95,75.96 86.88,75.03 86.88,74.87 87.1,74.65 87.1,73.9 87.2,73.8 87.51,73.8 87.64,73.67 87.64,73.27 87.51,73.14 87.1,73.14 86.88,72.92 86.88,72.84 86.88,72.84 86.88,71.79 87.12,71.54 89.55,71.54 89.67,71.41 89.67,70.4 89.55,70.27 89.04,70.27 v1(88.53,70.78)
DDR_D13: length 35.9
  TOP w0.102: v2(86.6,79.4) U2.L3
  TOP w0.121: U34.E8 80.78,58.24 80.78,58.91 81.32,59.45 85.05,59.45 85.18,59.32 85.18,57.85 85.3,57.72 86.4,57.72 86.52,57.85 86.52,59.77 86.8,60.05 86.83,60.05 86.96,60.17 86.96,64.98 86.67,65.27 86.67,67.27 86.52,67.43 86.52,67.82 88.29,69.6 88.52,69.6 89.78,70.85 v1(90.41,70.85)
  BOTTOM w0.121: v1(90.41,70.85) 90.41,71.72 89.79,72.34 89.45,72.34 89.32,72.47 89.32,73.6 89.19,73.72 88.38,73.72 88.02,74.08 88.02,74.08 87.13,74.97 87.13,76.44 87.01,76.57 86.73,76.57 86.6,76.69 v2(86.6,79.4)
DDR_D14: length 35.9
  TOP w0.102: U2.L4 v2(86.6,80.2)
  TOP w0.127: v1(82.21,68.85) 82.21,68.4 81.8,67.99 80.29,67.99 80.03,68.26 80.03,68.62 80.04,68.63 80.04,68.85 79.91,68.97 78.72,68.97 78.6,68.85 78.6,67.59 79.12,67.07 80.56,67.07 80.68,66.94 80.68,64.3 80.38,64 80.38,63.91 80.19,63.71 80.12,63.71 80,63.59 80,63.16 80.1,63.05 80.76,63.05 U34.D2
  LY4 w0.133: v1(89.88,73.14) 88.72,73.14 88.6,73.01 88.6,72.34 88.61,72.33 88.61,72.05 87.06,70.5 87.06,69.61 86.3,68.85 v1(82.21,68.85)
  BOTTOM w0.121: v2(86.6,80.2) 87.01,79.79 87.01,77.38 87.15,77.24 87.15,77.24 87.46,76.92 87.46,75 88.06,74.41 89.82,74.41 90.74,73.49 90.74,73.27 90.61,73.14 v1(89.88,73.14)
DDR_D15: length 35.8
  TOP w0.121: U2.M1 87,77.16 87.44,76.71 87.44,75.03 87.97,74.51 88.66,74.51 90.69,74.51 92.21,72.98 92.21,71.69 92.09,71.56 90.13,71.56 89.67,71.11 89.67,71.11 88.41,69.85 88.19,69.85 86.26,67.92 86.26,67.32 86.42,67.17 86.42,60.03 86.27,59.88 86.27,58.28 86.14,58.15 85.56,58.15 85.43,58.28 85.43,59.6 85.3,59.73 80.69,59.73 80.43,59.47 80.43,59.01 80.38,58.96 U34.E7
DDR_DQM0: length 35.6
  TOP w0.121: v1(97.78,59.04) U33.B7
  TOP w0.127: v1(93.89,71.67) 90.79,74.76 88.88,74.76 88.88,74.76 88.68,74.76 88.68,74.76 88.07,74.76 87.7,75.14 87.7,77.01 87.39,77.31 87.39,78.87 87.27,79 U2.M2
  BOTTOM w0.121: v1(97.78,59.04) 98.18,59.04 98.32,58.89 100.85,58.89 101.74,59.78 101.74,65.82 101.18,66.38 99.22,66.38 98.82,66.79 98.82,70.81 98.3,71.33 94.68,71.33 94.35,71.67 v1(93.89,71.67)
DDR_DQM1: length 35.9
  TOP w0.121: v1(90.54,69.68) 90.53,69.68 90.23,69.98 89.65,69.98 88.34,68.68 88.33,68.68 87.73,68.09 87.73,67.21 87.18,66.66 87.18,65.5 87.46,65.21 87.46,59.79 87.39,59.71 87.39,58.82 87.26,58.69 87.16,58.69 87.03,58.57 87.03,56.76 86.93,56.65 84.77,56.65 84.67,56.76 84.67,58.61 84.54,58.74 83.92,58.74 83.71,58.95 83.09,58.95 U34.B7
  TOP w0.127: U2.J2 84.6,78.99 85,78.59 85,78.04 85.42,77.62 85.42,77.58 85.44,77.56 85.44,77.13 85.25,76.95 v1(85.25,76.3)
  BOTTOM w0.121: v1(90.54,69.68) 90.22,70 88.19,70 88.05,70.14 88.05,71.16 87.92,71.28 87.02,71.28 86.62,71.68 86.62,72.94 86.63,72.95 86.63,73.65 86.84,73.86 86.84,74.55 86.63,74.76 86.63,74.93 85.7,75.85 85.7,75.86 v1(85.25,76.3)
DDR_DQS0: length 35.6
  TOP w0.095: U2.P1 88.6,77.83 88.81,77.62 89.06,77.62 89.21,77.47 89.33,77.47 89.39,77.41 89.41,77.41 90.02,76.8 90.56,76.8 93.13,74.23 94.98,74.23 95.39,73.82 95.39,71.94 96.02,71.31 101.21,71.31 102.73,69.79 102.73,63.5 101.52,62.29 100.29,62.29 99.74,61.75 99.45,61.75 99.33,61.62 99.33,61.33 99.1,61.1 98.59,61.1 98.46,60.97 98.46,60.72 98.34,60.59 98.06,60.59 97.93,60.72 97.93,60.9 97.8,61.02 97.6,61.02 97.47,60.9 97.47,60.72 97.34,60.59 97.08,60.59 96.94,60.74 96.94,60.92 96.82,61.04 96.82,61.25 96.99,61.42 96.99,62.17 96.87,62.29 96.7,62.29 96.58,62.17 U33.C3
DDR_DQS1: length 35.3
  TOP w0.095: U2.L1 86.2,77.85 86.34,77.7 86.34,76.88 86.37,76.85 86.37,76.84 86.68,76.53 86.68,76.36 86.55,76.24 86.45,76.24 86.32,76.11 86.32,75.83 86.45,75.7 86.55,75.7 86.68,75.58 86.68,75.37 86.55,75.25 86.3,75.25 86.17,75.12 86.17,74.94 86.3,74.81 86.55,74.81 86.68,74.69 86.68,74.33 87.18,73.82 90.52,73.82 91.3,73.05 91.3,72.42 91.19,72.3 89.51,72.3 88.82,71.61 86.76,71.61 86.73,71.59 86.45,71.31 86.45,70.75 86.75,70.45 86.99,70.45 87.08,70.35 87.08,70.03 86.97,69.91 86.18,69.91 85.89,69.62 85.89,68.89 85.67,68.67 84.73,68.67 84.44,68.38 84.44,65.87 84.8,65.52 85.28,65.52 85.41,65.39 85.41,60.84 85.28,60.72 81.66,60.72 81.48,60.9 81.48,61.69 81.62,61.84 U34.C3
DDR_DQSN0: length 35.9
  TOP w0.095: U2.P2 89.07,78.53 89.07,78.09 89.09,78.07 89.09,78.05 89.29,77.85 89.38,77.85 89.4,77.83 89.42,77.83 89.6,77.66 89.6,77.61 90.13,77.08 90.68,77.08 93.24,74.51 95.1,74.51 95.67,73.94 95.67,72.06 96.14,71.59 101.32,71.59 103.01,69.9 103.01,63.38 101.64,62.01 100.42,62.01 98.72,60.31 96.18,60.31 95.8,60.69 95.8,61.48 95.78,61.5 U33.D3
DDR_DQSN1: length 35.7
  TOP w0.095: U2.L2 86.63,78.57 86.63,76.97 86.98,76.62 86.98,74.42 87.3,74.1 90.64,74.1 91.58,73.16 91.58,72.3 91.3,72.02 89.63,72.02 88.91,71.31 86.85,71.31 86.73,71.19 86.73,70.86 86.84,70.75 87.08,70.75 87.36,70.47 87.36,69.91 87.08,69.63 86.3,69.63 86.17,69.51 86.17,68.77 85.79,68.39 84.85,68.39 84.72,68.26 84.72,65.99 84.91,65.8 85.4,65.8 85.69,65.51 85.69,60.73 85.4,60.44 81.55,60.44 81.18,60.81 U34.D3
DDR_ODT: length 59
  TOP w0.121: U2.G1 83,77.82 82.94,77.77 82.94,77.23 82.64,76.92 82.64,73.6 82.83,73.42 82.83,72.62 83.01,72.43 83.01,70.05 83.02,70.05 83.02,68.68 83.02,68.68 v1(83.02,68.24) ; U33.G1 v1(92.98,63.84) 92.41,64.4 88.4,64.4 v1(88.12,64.68)
  TOP w0.127: v1(78.27,65.87) 78.78,65.37 U34.G1
  LY4 w0.133: v1(83.02,68.24) 83.47,68.24 83.75,68.52 86.24,68.52 86.37,68.39 86.37,68.01 86.24,67.88 84.26,67.88 84.14,67.75 84.14,67.47 84.26,67.35 85.64,67.35 85.76,67.22 85.76,66.94 85.64,66.81 83.27,66.81 82.17,67.92 80.01,67.92 79.79,67.7 79.79,67.27 79.92,67.14 82,67.14 82.13,67.02 82.13,66.69 82,66.57 78.4,66.57 78.27,66.44 v1(78.27,65.87) 78.58,66.19 87.01,66.19 88.12,65.07 v1(88.12,64.68)
  BOTTOM w0.121: R623.2 92.17,66.2 92.3,66.08 92.3,65.25 92.47,65.09 92.94,65.09 93.15,64.87 93.15,64.65 93.03,64.53 92.29,64.53 92.04,64.78 91.86,64.78 91.73,64.65 91.73,64.1 91.86,63.97 92.11,63.97 92.24,63.84 92.24,63.55 92.37,63.43 92.57,63.43 v1(92.98,63.84)
DDR_RASN: length 62.2
  TOP w0.102: U2.G4 v2(82.6,80.2)
  TOP w0.121: v1(79.98,61.44) U34.F3 ; v1(96.94,65.47) 97.52,65.47 97.65,65.59 97.65,66.08 97.52,66.2 R600.2 ; U33.F3 v1(93.78,61.44)
  TOP w0.127: v1(82.59,66.84) v1(83.25,67.5)
  LY4 w0.076: 87.37,59.64 87.66,59.64 87.74,59.73 89.69,59.73 90.05,59.36 90.36,59.36 90.43,59.43 94.04,59.43 94.17,59.56 94.17,60.72 94.04,60.84 93.91,60.84 93.78,60.97 v1(93.78,61.44)
  LY4 w0.127: 87.29,59.64 87.37,59.64
  LY4 w0.133: v1(96.94,65.47) 95.97,64.5 95.24,64.5 94.73,63.99 94.73,62.38 v1(93.78,61.44) ; v1(79.98,61.44) 83.6,61.44 83.73,61.31 83.73,60.24 83.86,60.11 85.71,60.11 86.18,59.64 87.29,59.64
  BOTTOM w0.121: v1(83.25,67.5) 82.99,67.5 82.82,67.68 80.15,67.68 80.02,67.8 80.02,68.64 80.39,69.01 80.69,69.01 80.84,69.16 81.26,69.16 81.39,69.29 81.39,69.79 81.51,69.91 82.78,69.91 82.9,69.79 82.9,69.1 83.06,68.95 84.47,68.95 85.2,69.68 85.2,69.86 83.46,71.6 82.32,71.6 82.06,71.86 82.06,74.23 81.94,74.36 80.74,74.36 80.61,74.48 80.61,76.06 81.16,76.61 81.16,77.15 82.99,78.98 82.99,79.81 v2(82.6,80.2) ; v1(79.98,61.44) 81.2,61.44 82.79,63.03 82.79,64.38 82.91,64.5 82.92,64.5 83.04,64.63 83.04,66.38 v1(82.59,66.84)
DDR_RESETN: length 55.3
  TOP w0.102: U2.G2 83,79 83.35,78.65 v2(83.35,77.63)
  TOP w0.121: v1(76.3,73.46) 76.3,73.9 76.06,74.14 74.54,74.14 74.28,73.88 74.28,71.56 74.05,71.33 72.48,71.33 72.22,71.08 72.22,70.4 71.97,70.14 70.93,70.14 70.67,69.89 70.67,65.75 71.41,65.01 72.39,65.01 72.62,64.78 72.62,63.8 73.29,63.13 73.29,62.52 v1(73.58,62.24) U34.N2 ; v1(88.18,63.04) U33.N2
  LY4 w0.076: v1(73.58,62.24) 74.75,63.4 74.75,64.13 75.04,64.43 75.25,64.43 75.49,64.67 ; v1(88.18,63.04) 88.18,63.04 88.18,63.31 87.77,63.71 87.77,64.4 87.67,64.5 87.67,64.65
  LY4 w0.127: 75.69,64.87 75.69,64.99 75.95,65.25 76.05,65.25
  LY4 w0.133: 76.05,65.25 78.44,65.25 79.01,65.82 86.5,65.82 87.67,64.65 ; v1(76.3,73.46) 76.61,73.77 77.77,73.77 77.9,73.9 77.9,74.48 78.03,74.61 78.28,74.61 78.41,74.48 78.41,73.9 78.54,73.77 78.79,73.77 78.92,73.9 78.92,74.48 79.04,74.61 79.3,74.61 79.42,74.48 79.42,73.9 79.55,73.77 79.81,73.77 79.93,73.9 79.93,74.48 80.06,74.61 80.31,74.61 80.44,74.48 80.44,73.9 80.57,73.77 81.88,73.77 83.4,75.3 83.4,77.19 83.35,77.24 v2(83.35,77.63) ; 75.49,64.67 75.69,64.87
  BOTTOM w0.121: R630.1 87.93,63.04 v1(88.18,63.04)
DDR_WEN: length 62
  TOP w0.121: v1(67.73,66.71) 67.73,65.69 73.47,59.96 77.23,59.96 77.58,60.31 v1(77.58,61.44) U34.H3 ; U2.B2 79.25,79 79.38,78.87 79.38,78.01 78.77,77.4 78.77,77.35 78.42,77 75.4,77 73.97,75.57 73.97,74.43 73.69,74.15 72.68,74.15 72.55,74.03 72.55,72.25 72.15,71.84 70.9,71.84 69.96,70.9 v1(69.96,68.52) ; R602.2 v1(95.92,65.44) ; v1(92.18,61.44) U33.H3
  LY4 w0.076: 87.4,60.16 89.66,60.16 89.75,60.25 90.42,60.25 90.61,60.06 91.65,60.06 92.26,60.67 92.26,60.98 92.18,61.07 v1(92.18,61.44) 92.55,61.8 92.55,62.53 92.77,62.75 93.1,62.75 93.2,62.85 93.78,62.85 94.47,63.55 94.47,64.25 ; v1(77.58,61.44) 77.95,61.81 79.44,61.81 79.56,61.94 79.56,62.37 79.8,62.6 84.23,62.6 84.42,62.42
  LY4 w0.133: v1(95.92,65.44) 95.54,65.06 95.29,65.06 94.47,64.25 ; 84.42,62.42 84.42,60.92 84.66,60.67 86.12,60.67 86.4,60.39 86.4,60.3 86.55,60.16 87.4,60.16
  BOTTOM w0.121: v1(69.96,68.52) 69.52,68.52 68.04,67.04 68.04,67.02 v1(67.73,66.71)
EECS: length 6.9
  TOP w0.121: U58.63 11.77,84.91 11.78,84.91 11.78,85.89 9.94,87.73 U61.1
EEDATA: length 7.1
  TOP w0.121: U61.3 12.48,88.94 R587.1 11.47,87.42 11.49,87.39 11.49,87.11 12.42,86.18 12.42,85.2 12.77,84.85 U58.61
EESK: length 7
  TOP w0.121: U61.2 11.21,89.01 10.81,88.61 10.81,87.24 11.94,86.1 11.94,86.09 12.03,86 12.03,85.07 12.27,84.83 U58.62
EMU2: length 53.9
  TOP w0.121: 24,86.65 v1(22.14,86.65) ; v1(21.12,89.32) 21.63,89.83 26.58,89.83 27.94,91.19 31.75,91.19 32.7,92.13 47.24,92.13 48.22,93.11 56.03,93.11 57.37,94.44 59.49,94.44 60.34,95.29 64.12,95.29 64.94,94.46 65.73,94.46 66.18,94.02 R76.1
  BOTTOM w0.121: v1(22.14,86.65) 21.6,86.65 21.12,87.13 v1(21.12,89.32)
EMU3: length 40.2
  TOP w0.121: R77.1 63.48,93.57 62.71,93.57 61.59,92.45 57.31,92.45 57.23,92.37 48.68,92.37 46.9,90.59 35.62,90.59 35.21,91 33.27,91 32.04,89.78 32.04,87.03 31.66,86.65 J2.18
EMU4: length 62.5
  TOP w0.121: v1(20.1,89.32) 20.87,88.56 26.2,88.56 27.47,89.83 31.53,89.83 32.96,91.25 47.19,91.25 48.55,92.61 56.24,92.61 57.19,93.57 59.22,93.57 59.73,93.06 61.31,93.06 62.39,94.14 63.86,94.14 64.57,93.44 64.96,93.44 65.65,92.75 67.66,92.75 68.48,91.93 70.05,91.93 70.75,91.22 R78.1 ; 24,85.38 v1(22.14,85.38)
  BOTTOM w0.121: v1(20.1,89.32) 20.1,86.65 21.37,85.38 v1(22.14,85.38)
EMU_RSTN: length 6.4
  TOP w0.121: R517.1 v1(22.14,87.92) 24,87.92
  BOTTOM w0.121: C260.1 23.53,86.65 23.15,87.03 23.15,87.54 22.77,87.92 v1(22.14,87.92)
EMU_USB_DM: length 30.6
  TOP w0.114: 7.67,100.14 7.47,99.94 5.11,99.94 4.93,100.13 J40.2 ; 7.67,100.14 U57.5 ; 7.67,100.14 7.86,99.94 8.69,99.94 8.7,99.94 9.46,99.94 10.05,99.34 10.05,98.71 v1(10.33,98.43)
  TOP w0.121: U58.7 v1(10.52,79.02)
  BOTTOM w0.114: v1(10.52,79.02) 10.17,78.68 10.02,78.68 9.66,79.03 9.66,80.66 10.2,81.19 10.2,83.22 9.31,84.11 9.31,96.73 10.05,97.48 10.05,98.15 v1(10.33,98.43)
EMU_USB_DP: length 30.8
  TOP w0.114: v1(9.49,98.43) 9.77,98.71 9.77,99.23 9.34,99.66 8.82,99.66 8.67,99.5 ; 8.67,99.5 8.51,99.66 5.11,99.66 4.93,99.48 J40.3 ; 8.67,99.5 U57.3
  TOP w0.121: U58.8 10.26,78.52 v1(10.6,78.18)
  BOTTOM w0.114: v1(10.6,78.18) 10.38,78.4 9.9,78.4 9.38,78.92 9.38,80.77 9.92,81.31 9.92,83.11 9.03,84 9.03,96.85 9.77,97.59 9.77,98.15 v1(9.49,98.43)
ENZ_KALDO_1P8V: length 9.6
  TOP w0.102: 77.34,79.83 77.76,79.41 78.33,79.41 78.64,79.72 78.64,80.24 U2.B4
  TOP w0.121: 77.34,79.83 76.63,79.83 75.97,79.17 72,79.17 R48.2
ETH_INTN: length 118.5
  TOP w0.121: R404.1 80.91,103.57 80.91,105.47 80.01,106.37 80.01,107.25 78.56,108.7 66.59,108.7 66.08,108.19 v1(64.24,108.19) ; U25.5 28.99,55.76 v1(28.85,55.89) ; v1(63.82,102.91) 63.32,103.41 57.35,103.41 56.26,104.49 54.02,104.49 51.45,101.92 49.64,101.92 46.8,99.07 43.12,99.07 42.38,98.34 34.5,98.34 34.3,98.54 v1(32.35,98.54)
  BOTTOM w0.121: v1(28.85,55.89) 28.52,55.89 28.34,55.71 28.33,55.71 28.15,55.54 27.01,55.54 26.5,56.04 26.5,57.01 25.88,57.63 25.88,58.54 25.59,58.84 R409.1 24.8,58.08 23.53,58.08 23.15,58.46 23.15,61.38 22.39,62.14 22.39,64.05 24.09,65.75 25.14,65.75 26.9,67.51 26.9,81.74 32.32,87.16 32.32,91.73 32.4,91.8 32.4,98.05 32.35,98.1 v1(32.35,98.54) ; v1(63.82,102.91) 64.4,102.91 65.16,103.67 65.16,104.18 64.17,105.17 64.17,107.68 64.24,107.75 v1(64.24,108.19)
ETH_MDIO_CLK: length 134
  TOP w0.121: v1(91.35,99.22) 91.1,98.97 R433.1 ; U25.1 30.09,57.38 30.09,57.67 v1(29.65,58.1)
  LY3 w0.133: v1(92.62,111.52) 90.26,111.52 89.02,112.75 87.73,112.75 87.34,112.37 86.99,112.37 86.22,111.59 52.23,111.59 51.93,111.9 46.98,111.9 42.62,107.54 34.29,107.54 34.16,107.67 33.38,107.67 v1(33.11,107.4)
  BOTTOM w0.121: v1(92.62,111.52) 92.62,112 92.49,112.13 92.11,112.13 91.98,112 91.98,110.85 92.1,110.73 92.75,110.73 92.87,110.61 92.87,110.37 92.75,110.25 92.1,110.25 91.98,110.13 91.98,109.29 92.98,108.29 92.98,102.59 92.46,102.07 92.46,102.07 91.71,101.31 91.71,99.58 91.66,99.54 91.66,99.54 v1(91.35,99.22) ; v1(29.65,58.1) 29.63,58.1 29.08,58.65 28.68,58.65 28.22,59.11 28.22,59.48 R407.2 27.72,81.72 32.82,86.82 32.82,91.47 32.9,91.55 32.9,97.83 33.03,97.96 33.03,99.04 33.56,99.57 33.56,106.95 v1(33.11,107.4)
ETH_MDIO_DATA: length 134.6
  TOP w0.121: v1(30.53,60.08) 30.77,59.84 30.77,59.04 30.98,58.83 U25.48 ; R434.1 v1(93.68,100.88)
  LY3 w0.133: v1(33.97,107.23) 47.56,107.23 50.28,109.94 59.67,109.94 60.21,110.48 60.29,110.48 60.79,110.98 84.34,110.98 84.64,110.68 89.75,110.68 90.05,110.98 95.42,110.98 95.47,111.04 v1(95.92,111.04)
  BOTTOM w0.121: v1(30.53,60.08) 30.9,60.44 R408.1 28.54,63.36 28.54,82.08 33.15,86.7 33.15,97.6 33.28,97.73 33.28,98.54 33.97,99.23 v1(33.97,107.23) ; v1(93.68,100.88) 93.99,100.88 96.86,103.75 96.86,109.99 96.73,110.12 96.46,110.12 96.33,109.99 96.33,107.86 96.2,107.73 95.8,107.73 95.67,107.86 95.67,110.78 v1(95.92,111.04)
ETH_RBIAS: length 4.6
  TOP w0.121: v1(28.36,54.52) 28.76,54.11 29.46,54.11 29.51,54.16 U25.9
  BOTTOM w0.381: v1(28.36,54.52) 28.36,55 28.68,55.32 29.09,55.32 29.43,55.66 R406.2
ETH_REFCLK: length 148.7
  TOP w0.121: R432.1 80.45,108.11 78.94,109.62 65.91,109.62 65.7,109.41 51.8,109.41 51.67,109.28 51.67,108.02 51.31,107.66 50.83,107.66 50.7,107.53 50.7,105.14 50.57,105.02 39.25,105.02 38.77,105.5 38.77,109.46 39.38,110.07 v1(41.34,110.07) ; U25.25 36.87,52.96 36.92,52.91 36.92,52.91 37.1,52.74 v1(37.12,52.74)
  BOTTOM w0.121: v1(41.34,110.07) 41.34,110.03 41.03,109.73 41.03,100.62 41.03,100.27 39.59,98.82 39.58,98.82 39.34,98.58 39.08,98.31 39.08,98.31 38.82,98.06 38.82,85.75 38.24,85.17 38.24,83.84 35.36,80.96 35.36,68.6 40.07,63.89 40.07,60.11 39.8,59.84 39.8,52.9 41.44,51.27 41.44,49.03 41.31,48.91 40.44,48.91 40.32,49.03 40.32,51.66 40.19,51.78 39.95,51.78 39.83,51.66 39.83,49.47 39.71,49.34 39.47,49.34 39.34,49.47 39.34,57.11 39.22,57.24 38.99,57.24 38.86,57.11 38.86,50.37 38.74,50.25 37.45,50.25 37.12,50.58 37.12,50.96 37.24,51.08 37.74,51.08 37.86,51.2 37.86,51.44 37.74,51.56 37.24,51.56 37.12,51.68 v1(37.12,52.74)
ETH_RESETN: length 7.3
  TOP w0.121: U25.2 29.63,56.96 29.5,57.08 29.5,57.09 29.22,57.36 v1(29.22,57.52) ; v1(25.18,59.85) 25.05,59.99 U26.4
  BOTTOM w0.121: v1(29.22,57.52) 29.04,57.52 R391.1 27.15,59.41 25.71,59.41 25.65,59.47 25.56,59.47 v1(25.18,59.85)
ETH_RXCLK: length 5.9
  TOP w0.121: U25.33 36.77,56.16 36.81,56.11 37.33,56.11 37.86,56.64 37.86,57.19 38.24,57.57 39.6,57.57 R422.2 R423.1
ETH_RXD0: length 5.1
  TOP w0.121: R424.1 R411.2 39.59,55.02 38.78,55.02 38.74,54.98 38.07,54.98 37.69,55.36 U25.31
ETH_RXD1: length 5.2
  TOP w0.121: R425.1 R413.2 39.6,54.77 38.88,54.77 38.84,54.73 37.75,54.73 37.4,55.08 36.9,55.08 36.78,54.96 U25.30
ETH_RXD2: length 5.2
  TOP w0.121: U25.28 36.86,54.16 36.9,54.11 37.43,54.11 37.93,53.61 39.5,53.61 R419.2 R427.1
ETH_RXD3: length 5.9
  TOP w0.121: U25.27 36.86,53.76 36.92,53.81 37.31,53.81 37.54,53.58 37.54,53.08 38.34,52.29 39.56,52.29 39.75,52.1 39.75,52.08 R426.2 R428.1
ETH_RXDV: length 5.2
  TOP w0.121: U25.32 37.5,55.76 37.84,56.09 39.39,56.09 R414.2 R430.1
ETH_TXCLK: length 137.8
  TOP w0.121: v1(37.27,58.86) 37.27,59.35 37.43,59.5 37.43,59.8 37.27,59.96 37.27,62.01 37.4,62.14 40.63,62.14 40.75,62.01 40.75,61.48 40.63,61.35 39,61.35 38.87,61.23 38.87,60.77 38.95,60.69 40.4,60.69 40.52,60.57 40.52,60.22 40.4,60.1 38.09,60.1 37.85,59.86 37.85,58.55 37.68,58.39 37.68,58 37.55,57.87 37.12,57.87 36.99,57.75 36.99,57.14 36.8,56.96 U25.35 ; v1(87.16,112.81) 86.29,112.81 86.12,112.64 82.48,112.64 81.57,113.55 61.54,113.55 61.07,113.07 51.71,113.07 51.37,112.74 45.55,112.74 45.43,112.86 45.43,112.97 45.31,113.09 45.07,113.09 44.95,112.97 44.95,112.86 44.83,112.74 44.59,112.74 44.47,112.86 44.47,112.97 44.35,113.09 44.1,113.09 43.98,112.97 43.98,112.86 43.86,112.74 43.62,112.74 43.5,112.86 43.5,112.97 43.38,113.09 43.14,113.09 43.02,112.97 43.02,112.86 42.9,112.74 42.13,112.74 41.83,113.04 v1(41.39,113.04)
  BOTTOM w0.121: v1(37.27,58.86) 38.53,60.12 38.53,60.32 38.98,60.77 38.98,63.28 33.82,68.44 33.82,68.75 33.78,68.79 33.78,69.16 33.9,69.28 33.9,81.43 36.84,84.37 36.84,85.43 37.72,86.31 37.72,98.85 37.7,98.87 37.7,99.01 39.89,101.2 39.89,110.98 40.35,111.44 40.35,111.97 40.78,112.4 40.78,112.43 v1(41.39,113.04) ; v1(87.16,112.81) 87.16,112.38 87.03,112.25 87.03,102.85 86.88,102.7 R415.1
ETH_TXD0: length 141
  TOP w0.121: v1(36.26,57.87) U25.36 ; v1(39.64,113.78) 39.64,115.75 39.76,115.88 40.32,115.88 40.43,115.77 40.43,114.56 40.55,114.44 40.79,114.44 40.91,114.56 40.91,115.1 41.03,115.22 41.27,115.22 41.39,115.1 41.39,114.56 41.51,114.44 41.75,114.44 41.87,114.56 41.87,115.1 42,115.22 43.34,115.22 43.34,115.22 43.61,115.22 44.9,116.51 64.01,116.51 64.88,115.63 64.97,115.63 65.01,115.59 82.46,115.59 83.01,116.14 v1(85.2,116.14) ; R416.1 86.19,100.11 85.53,100.77 85.53,101.87 v1(85.13,102.27)
  BOTTOM w0.121: v1(85.13,102.27) 85.13,104.64 85.25,104.77 85.3,104.77 85.43,104.9 85.43,114.95 85.2,115.17 v1(85.2,116.14) ; v1(39.64,113.78) 39.95,114.09 39.95,114.47 40.74,115.26 41.38,115.26 41.62,115.02 41.62,114.29 41.44,114.11 40.96,114.11 40.42,113.56 40.39,113.56 40.1,113.27 40.1,112.68 39.46,112.04 39.46,111.5 38.82,110.87 38.82,101.64 37,99.82 37,98.39 37,87.59 36.17,86.76 36.17,84.64 33.02,81.5 33.02,81.04 33.04,81.02 33.04,79.95 32.92,79.83 32.56,79.83 32.44,79.71 32.44,79.47 32.56,79.35 32.92,79.35 33.04,79.23 33.04,78.98 32.92,78.86 32.56,78.86 32.44,78.74 32.44,78.5 32.56,78.38 32.92,78.38 33.04,78.26 33.04,78.02 32.92,77.9 32.56,77.9 32.44,77.78 32.44,77.54 32.56,77.42 32.88,77.42 33.01,77.29 33.01,76.22 32.88,76.09 32.73,76.09 32.6,75.97 32.6,75.74 32.73,75.61 32.92,75.61 33.04,75.49 33.04,67.19 35.62,64.61 36.33,64.61 36.83,64.11 37.76,63.18 37.76,61.16 36.29,59.7 36.29,58.93 36.26,58.9 v1(36.26,57.87)
ETH_TXD1: length 138.6
  TOP w0.121: v1(39.66,112.86) 40.48,112.04 64.72,112.04 65.54,112.86 69.67,112.86 69.68,112.87 70.04,112.87 70.05,112.86 79.51,112.86 80.62,111.76 86.36,111.76 86.55,111.95 87.52,111.95 87.62,112.05 88.05,112.05 88.4,112.41 89.29,112.41 89.47,112.23 v1(89.47,111.44) ; R417.1 88.49,99.56 v1(89.15,100.22) ; v1(35.85,59.12) 35.85,58.48 35.6,58.23 U25.37
  BOTTOM w0.121: v1(35.85,59.12) 35.85,59.86 37.29,61.3 37.29,63.04 36.4,63.93 36.15,64.18 35.44,64.18 35.2,64.43 32.02,67.61 32.02,81.09 35.74,84.82 35.74,86.93 36.58,87.77 36.58,99.99 38.4,101.81 38.4,102.06 38.28,102.18 37.93,102.18 37.81,102.31 37.81,102.54 37.93,102.66 38.28,102.66 38.4,102.78 38.4,103.03 38.28,103.15 36.95,103.15 36.83,103.27 36.83,103.51 36.95,103.63 38.28,103.63 38.4,103.75 38.4,103.99 38.28,104.11 36.95,104.11 36.83,104.23 36.83,104.47 36.95,104.59 38.28,104.59 38.4,104.72 38.4,104.96 38.28,105.08 36.95,105.08 36.83,105.2 36.83,105.44 36.95,105.56 38.28,105.56 38.4,105.68 38.4,105.93 38.28,106.05 37.27,106.05 37.15,106.17 37.15,106.41 37.27,106.53 38.28,106.53 38.4,106.65 38.4,111.04 39.04,111.68 39.04,112.24 v1(39.66,112.86) ; v1(89.15,100.22) 89.15,100.77 89.16,100.77 89.16,105.93 89.62,106.39 89.62,110.85 89.47,111 v1(89.47,111.44)
ETH_TXD2: length 138.6
  TOP w0.121: v1(89.19,99.35) 89.45,99.1 R418.1 ; v1(35.22,59.09) 34.98,58.86 U25.38 ; v1(88.71,111.61) 87.79,111.61 87.69,111.52 86.91,111.52 86.72,111.33 80.24,111.33 79.83,111.75 65.02,111.75 64.9,111.62 39.52,111.62 39.04,112.1 v1(38.59,112.1)
  BOTTOM w0.121: v1(35.22,59.09) 35.22,61.28 35.37,61.43 35.65,61.43 35.99,61.09 36.47,61.09 36.87,61.49 36.87,62.87 35.98,63.76 35.27,63.76 34.77,64.25 31.13,67.9 31.13,68.23 31.01,68.35 30.91,68.35 30.79,68.47 30.79,68.71 30.91,68.84 31.01,68.84 31.13,68.96 31.13,69.2 31.01,69.32 30.91,69.32 30.79,69.44 30.79,69.68 30.91,69.8 31.01,69.8 31.13,69.92 31.13,70.16 31.01,70.28 30.91,70.28 30.79,70.4 30.79,70.64 30.91,70.77 31.01,70.77 31.13,70.89 31.13,71.13 31.01,71.25 30.91,71.25 30.79,71.37 30.79,71.61 30.91,71.73 31.01,71.73 31.13,71.85 31.13,72.09 31.01,72.21 30.91,72.21 30.79,72.33 30.79,72.58 30.91,72.7 31.01,72.7 31.13,72.82 31.13,73.06 31.01,73.18 30.91,73.18 30.79,73.3 30.79,73.54 30.91,73.66 31.01,73.66 31.13,73.78 31.13,74.02 31.01,74.14 30.91,74.14 30.79,74.26 30.79,74.51 30.91,74.63 31.01,74.63 31.13,74.75 31.13,74.99 31.01,75.11 30.91,75.11 30.79,75.23 30.79,75.47 30.91,75.59 31.01,75.59 31.13,75.71 31.13,75.95 31.01,76.07 30.91,76.07 30.79,76.19 30.79,76.44 30.91,76.56 31.01,76.56 31.13,76.68 31.13,76.92 31.01,77.04 30.91,77.04 30.79,77.16 30.79,77.4 30.91,77.52 31.01,77.52 31.13,77.64 31.13,77.89 31,78.02 30.85,78.02 30.72,78.14 30.72,78.47 30.85,78.6 31,78.6 31.13,78.73 31.13,82.92 31.33,83.12 31.5,83.12 32.31,82.32 32.48,82.32 32.65,82.49 32.65,82.66 31.84,83.47 31.84,83.64 32.02,83.81 32.19,83.81 32.99,83 33.16,83 33.34,83.17 33.34,83.34 32.53,84.15 32.53,84.32 32.7,84.49 32.87,84.49 33.68,83.68 33.85,83.68 34.02,83.85 34.02,84.02 33.21,84.83 33.21,85 33.44,85.23 33.59,85.23 33.74,85.08 33.92,85.08 34.08,85.24 34.08,85.42 33.89,85.61 33.89,85.68 36.15,87.94 36.15,101.85 36.4,102.09 36.4,106.67 37.97,108.24 37.97,111.28 38.28,111.59 38.28,111.79 v1(38.59,112.1) ; v1(88.71,111.61) 88.71,110.68 89.17,110.22 89.17,106.74 88.71,106.29 88.71,99.83 v1(89.19,99.35)
ETH_TXD3: length 142.5
  TOP w0.121: v1(85.02,99.99) 85.02,99.2 R420.1 ; v1(36.33,61.58) 36.33,60.34 35.72,59.73 35.06,59.73 34.58,59.25 U25.39 ; v1(41.69,115.68) 43.37,117.36 64.55,117.36 65.38,116.53 73.12,116.53 73.69,117.11 v1(84.54,117.11)
  BOTTOM w0.121: v1(41.69,115.68) 40.56,115.68 39.05,114.18 39.05,113.27 37.55,111.77 37.55,108.41 35.98,106.84 35.98,102.27 35.73,102.02 35.73,88.12 30.13,82.52 30.13,76.3 30.01,76.18 29.68,76.18 29.55,76.05 29.55,75.83 29.68,75.7 30.01,75.7 30.13,75.58 30.13,75.34 30.01,75.22 29.33,75.22 29.21,75.1 29.21,74.85 29.33,74.73 30.01,74.73 30.13,74.61 30.13,74.37 30.01,74.25 29.33,74.25 29.21,74.13 29.21,73.89 29.33,73.77 30.01,73.77 30.13,73.65 30.13,73.41 30.01,73.29 29.33,73.29 29.21,73.17 29.21,72.92 29.33,72.8 30.01,72.8 30.13,72.68 30.13,72.44 30.01,72.32 29.33,72.32 29.21,72.2 29.21,71.96 29.33,71.84 30.01,71.84 30.13,71.72 30.13,71.48 30.01,71.36 29.33,71.36 29.21,71.24 29.21,70.99 29.33,70.87 30.01,70.87 30.13,70.75 30.13,70.51 30.01,70.39 29.33,70.39 29.21,70.27 29.21,70.03 29.33,69.91 30.01,69.91 30.13,69.79 30.13,69.55 30.01,69.43 29.33,69.43 29.21,69.3 29.21,69.06 29.33,68.94 30.01,68.94 30.13,68.82 30.13,68.29 34.34,64.08 35.09,63.33 35.8,63.33 36.41,62.72 36.41,62.1 36.33,62.02 v1(36.33,61.58) ; v1(85.02,99.99) 85.13,100.09 85.13,101.65 84.69,102.09 84.69,105.01 85,105.32 85,114.77 84.54,115.23 v1(84.54,117.11)
ETH_TXEN: length 140.9
  TOP w0.121: R421.1 85.6,98.82 85.6,99.43 85.47,99.56 85.47,100.17 84.93,100.7 84.93,101.41 84.69,101.66 84.69,108.12 82.79,110.02 80.1,110.02 80.1,110.02 79.75,110.02 79.3,110.47 65.55,110.47 65.36,110.27 51.14,110.27 50.63,109.76 48.69,109.76 48.57,109.64 48.57,107.48 48.44,107.35 48.22,107.35 48.09,107.48 48.09,109.64 47.97,109.76 47.73,109.76 47.61,109.64 47.61,106.41 47.49,106.29 47.24,106.29 47.12,106.41 47.12,109.64 47,109.76 46.76,109.76 46.64,109.64 46.64,106.41 46.52,106.29 46.28,106.29 46.16,106.41 46.16,109.64 46.04,109.76 45.8,109.76 45.68,109.64 45.68,106.41 45.56,106.29 45.31,106.29 45.19,106.41 45.19,109.64 45.07,109.76 44.7,109.76 43.65,110.81 v1(41.49,110.81) ; U25.34 v1(37.15,56.56)
  BOTTOM w0.121: v1(41.49,110.81) 41.05,110.81 40.61,110.36 40.61,100.44 39.4,99.24 39.4,99.24 39.04,98.88 38.65,98.49 38.65,98.49 38.4,98.23 38.4,85.93 37.81,85.34 37.81,84.01 34.93,81.14 34.93,68.43 39.65,63.71 39.65,60.28 39.38,60.01 39.38,58.5 38.26,57.39 37.98,57.39 37.46,56.87 37.46,56.87 v1(37.15,56.56)
ETHER_D0N: length 70.8
  TOP w0.095: U25.12 29.53,52.96 29.47,53.02 29.3,53.02 28.99,52.7 28.99,51.6 28.49,51.09 27.22,51.09 v1(26.83,50.71)
  BOTTOM w0.095: v1(26.83,50.71) 27.09,50.96 27.09,51.09 26.88,51.3 26.66,51.3 26.51,51.45 24.65,51.45 23.15,49.95 23.15,15.79 28.49,10.45 39.03,10.45 40.93,12.36 40.93,13.99 40.69,14.24 39,14.24 38.52,13.75 38.52,13.37 J15.10
ETHER_D0P: length 70.9
  TOP w0.095: v1(26.83,51.73) 27.19,51.37 28.37,51.37 28.71,51.71 28.71,52.82 29.19,53.29 29.47,53.29 29.53,53.36 U25.11
  BOTTOM w0.095: v1(26.83,51.73) 24.53,51.73 22.87,50.06 22.87,15.67 28.37,10.17 39.14,10.17 41.21,12.24 41.21,14.11 40.8,14.52 38.64,14.52 J15.9
ETHER_D1N: length 71
  TOP w0.095: v1(30.14,49.19) 29.65,49.67 29.65,50.21 30,50.56 30.27,50.56 30.4,50.43 31.38,50.43 31.76,50.81 31.76,51.54 31.78,51.57 U25.15
  BOTTOM w0.095: v1(30.14,49.19) 29.74,49.19 29.63,49.08 29.63,46.27 24.42,41.06 24.42,31.17 24.85,30.74 28.53,30.74 30.16,29.11 30.16,25.07 28.37,23.28 25.06,23.28 24.42,22.64 24.42,15.8 28.85,11.37 37.4,11.37 38.01,11.98 38.01,13.12 37.2,13.93 36.4,13.93 35.72,13.25 35.72,12.86 35.98,12.61 J15.8
ETHER_D1P: length 71.1
  TOP w0.095: U25.14 31.38,51.57 31.48,51.48 31.48,50.92 31.26,50.71 30.52,50.71 30.39,50.84 29.89,50.84 29.37,50.32 29.37,49.69 v1(28.87,49.19)
  BOTTOM w0.095: v1(28.87,49.19) 29.35,48.7 29.35,46.38 24.14,41.17 24.14,31.05 24.73,30.46 28.42,30.46 29.88,28.99 29.88,25.18 28.26,23.56 24.94,23.56 24.14,22.76 24.14,15.68 28.74,11.09 37.52,11.09 38.29,11.86 38.29,13.23 37.32,14.21 36.41,14.21 J15.7
ETHER_D2N: length 71
  TOP w0.095: v1(33.82,49.19) 33.46,49.19 33.33,49.31 33.33,49.66 33.04,49.95 32.22,49.95 32.04,50.13 32.04,50.38 32.22,50.56 32.65,50.56 32.96,50.86 32.96,52.05 U25.18
  BOTTOM w0.095: v1(33.82,49.19) 33.42,49.19 33.32,49.09 33.32,39.79 32.79,39.25 27.84,39.25 27.75,39.16 27.75,36.35 27.84,36.26 33.99,36.26 34.41,35.84 34.41,25.82 34.66,25.56 35.88,25.56 36.13,25.31 36.13,22.77 35.88,22.52 34.66,22.52 34.41,22.26 34.41,20.99 34.66,20.74 41.69,20.74 41.95,20.48 41.95,18.97 41.53,18.55 34.5,18.55 34.41,18.46 34.41,14.4 34.2,14.19 J15.6
ETHER_D2P: length 71.1
  TOP w0.095: v1(32.55,49.19) 32.92,49.19 33.05,49.31 33.05,49.54 32.92,49.67 32.1,49.67 31.76,50.01 31.76,50.49 32.1,50.84 32.53,50.84 32.68,50.98 32.68,51.99 U25.17
  BOTTOM w0.095: J15.5 32.93,14.52 33.18,14.26 33.88,14.26 34.13,14.52 34.13,18.58 34.38,18.83 41.41,18.83 41.67,19.09 41.67,20.37 41.58,20.46 34.55,20.46 34.13,20.88 34.13,22.38 34.55,22.8 35.76,22.8 35.85,22.89 35.85,25.19 35.76,25.28 34.55,25.28 34.13,25.7 34.13,35.72 33.88,35.98 27.72,35.98 27.47,36.23 27.47,39.28 27.72,39.53 32.68,39.53 33.04,39.9 33.04,49.09 32.95,49.19 v1(32.55,49.19)
ETHER_D3N: length 70.9
  TOP w0.095: v1(36.36,49.19) 35.86,49.69 35.86,50.07 35.91,50.13 35.91,50.7 35.62,50.99 35.03,50.99 34.84,50.8 34.37,50.8 34.12,51.04 34.12,52.02 U25.21
  BOTTOM w0.095: J15.4 31.15,13.12 31.15,13.75 31.25,13.85 31.27,13.85 31.94,14.53 31.94,17.81 31.52,18.22 25.82,18.22 25.56,18.48 25.56,21.63 25.82,21.88 31.66,21.88 32.07,22.29 32.07,32.9 31.51,33.46 26.83,33.46 26.58,33.72 26.58,41.07 26.67,41.16 31,41.16 31.53,41.69 31.53,49.41 31.79,49.67 34.08,49.67 34.3,49.45 34.3,48.56 34.72,48.14 35.59,48.14 35.85,48.4 35.85,49.06 35.85,49.14 35.96,49.23 v1(36.36,49.19)
ETHER_D3P: length 70.6
  TOP w0.095: U25.20 33.84,52.02 33.84,50.92 34.25,50.52 34.96,50.52 35.15,50.71 35.51,50.71 35.64,50.58 35.64,50.25 35.58,50.19 35.58,49.8 v1(35.09,49.31)
  BOTTOM w0.095: v1(35.09,49.31) 35.49,49.27 35.58,49.17 35.57,49.07 35.57,48.52 35.47,48.42 34.84,48.42 34.58,48.68 34.58,49.57 34.2,49.95 31.67,49.95 31.25,49.53 31.25,41.81 30.88,41.44 26.55,41.44 26.3,41.19 26.3,33.6 26.72,33.18 31.39,33.18 31.79,32.79 31.79,22.4 31.54,22.16 25.7,22.16 25.28,21.74 25.28,18.36 25.7,17.94 31.41,17.94 31.66,17.69 31.66,14.64 31.15,14.13 30.52,14.13 30.39,14.26 J15.3

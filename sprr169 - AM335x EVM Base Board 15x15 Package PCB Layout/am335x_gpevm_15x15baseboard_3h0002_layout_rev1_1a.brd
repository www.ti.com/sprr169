# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_1a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AM335X_MCASP0_AHCLKR: length 88.3
  TOP w0.102: v2(80.2,87.4) U2.C12
  TOP w0.121: R85.2 v1(85.66,156.27)
  LY4 w0.133: v1(69.2,91.47) 69.2,91.45 69.62,91.03 70.04,91.03 71.5,92.49 71.5,94.87 71.5,94.87 71.5,95.24 71.5,95.25 71.5,98.06 71.41,98.14 71.41,114.21 79.54,122.34 79.54,123.67 78.71,124.5 78.71,135.29 79.61,136.18 79.61,140.49 79.47,140.63 79.47,142.59 79.61,142.72 79.61,150.22 v1(85.66,156.27)
  BOTTOM w0.102: v2(80.2,87.4) 80.2,87.38 79.86,87.03 78.52,87.03 77.32,88.24 77.1,88.24
  BOTTOM w0.121: 77.1,88.24 73.05,88.24 71.7,89.58 71.07,89.58 69.87,90.78 69.57,90.78 69.18,91.17 69.18,91.45 v1(69.2,91.47)
AM335X_MCASP0_AHCLKX: length 60.2
  TOP w0.102: 77.1,89.05 77.55,88.6 U2.A14
  TOP w0.121: 77.1,89.05 76.74,89.41 75.86,89.41 74.88,90.39 70.26,90.39 69.87,90.78 68.93,90.78 67.85,91.86 66.19,91.86 64.86,93.19 64.46,93.19 63.84,93.82 62.45,93.82 61.44,92.81 59.03,92.81 58.84,93 v1(57.31,93) ; R352.1 47.54,113.96 47.99,113.96 48.42,114.38 48.42,114.46 48.42,114.46 48.42,115.1 49.26,115.94 57.79,115.94 58.09,115.63 v1(58.53,115.63)
  BOTTOM w0.121: v1(57.31,93) 57.31,94.02 57.57,94.27 57.57,108.88 58.85,110.16 58.85,114.98 58.84,114.98 58.84,115.32 v1(58.53,115.63)
AM335X_MCASP0_AXR0: length 145.4
  TOP w0.102: v2(81,87.4) U2.D12
  TOP w0.121: R451.1 87.54,155.57 86.05,154.08 85.55,154.08 85.31,153.84 84.69,153.84 84.45,154.08 81.63,154.08 81.56,154.15 v1(78.08,154.15) ; 29.5,124.75 34.58,124.75 38.91,120.43 68.04,120.43 68.36,120.75 73.13,120.75 74.92,122.55 78.23,122.55 78.53,122.85 v1(79.03,122.85)
  LY4 w0.133: v1(79.03,122.85) 71,114.82 71,111.47 70.01,110.48 70.01,99.61 v1(69.32,98.91)
  BOTTOM w0.102: 77.05,89.47 78.94,89.47 79.03,89.38 79.6,89.38 79.79,89.19 79.79,88.75 79.92,88.62 80.04,88.62 80.04,88.62 80.36,88.62 80.58,88.4 80.58,88.02 81,87.6 v2(81,87.4)
  BOTTOM w0.121: v1(69.32,98.91) 68.91,98.5 68.91,95.65 69.36,95.2 69.36,94.53 70.74,93.15 70.74,92.29 73.56,89.47 77.05,89.47 ; v1(78.08,154.15) 77.53,153.61 77.53,147.97 77.33,147.76 77.33,136.97 78.03,136.27 78.03,135.03 77.91,134.92 77.91,134.1 78.97,133.04 78.97,125.25 79.26,124.96 79.26,123.56 79.61,123.21 79.61,123.2 79.64,123.17 79.65,123.17 79.92,122.9 R203.1 v1(79.03,122.85)
AM335X_MCASP0_AXR1: length 110.1
  TOP w0.102: v2(80.2,88.2) U2.D13
  TOP w0.121: R318.2 50.02,128.11 39.86,128.11 v1(38.52,129.45)
  LY3 w0.133: v1(70.01,93.26) 65.32,93.26 62.36,90.3 57.73,90.3 55.15,87.73 34.11,87.73 v1(33.79,87.41)
  BOTTOM w0.102: v2(80.2,88.2) 80.2,88.21 80,88.42 79.84,88.42 79.63,88.62 78.97,88.62 78.61,88.98 77.1,88.98
  BOTTOM w0.121: v1(38.52,129.45) 38.04,128.97 37.4,128.97 35.85,127.42 35.85,113.5 34.4,112.05 34.4,107.42 34.41,107.41 34.41,107.04 34.4,107.03 34.4,98.49 33.46,97.55 33.46,87.74 v1(33.79,87.41) ; 77.1,88.98 73.35,88.98 70.19,92.14 70.18,92.14 69.84,92.48 69.84,93 70.01,93.18 v1(70.01,93.26)
AM335X_MCASP0_FSR: length 29.9
  TOP w0.102: v2(79.4,88.2) U2.C13
  TOP w0.121: R336.1 70.65,104.3 v1(69.44,104.3)
  BOTTOM w0.102: 77.1,88.73 77.81,88.73 78.35,88.2 v2(79.4,88.2)
  BOTTOM w0.121: 77.1,88.73 73.25,88.73 71.91,90.07 71.48,90.07 70.3,91.25 70.3,91.67 70.04,91.93 69.13,91.93 68.77,92.29 68.77,94.14 69.12,94.49 69.12,95.08 68.93,95.26 68.93,95.29 68.66,95.55 68.66,100.1 69.19,100.62 69.19,104.05 v1(69.44,104.3)
AM335X_MCASP0_FSX: length 58.8
  TOP w0.102: U2.B13 78.63,88.18 77.63,88.18 77.1,88.7
  TOP w0.121: 77.1,88.7 76.64,89.17 75.75,89.17 74.78,90.14 69.88,90.14 v1(69.69,90.34) ; R335.1 v1(82.46,121.83) ; v1(81,119.73) 75.98,119.73 74.5,118.25 67.89,118.25 v1(67.16,117.51)
  BOTTOM w0.121: R199.1 v1(82.46,121.83) 81.32,120.69 81.32,120.05 v1(81,119.73) ; v1(67.16,117.51) 67.16,116.56 68.66,115.06 68.66,112.71 68.8,112.56 68.8,111 68.94,110.86 68.94,104.16 68.94,104.15 68.94,100.72 68.42,100.2 68.42,95.42 68.87,94.97 68.87,94.6 68.52,94.25 68.52,91.04 69.22,90.34 v1(69.69,90.34)
AM335X_MMC2_CLK: length 2.3
  TOP w0.121: R459.1 19.37,108.9 19.37,109.21 19.49,109.33 20,109.33 20.46,108.87 U28.9
AM335X_MMC2_CMD: length 2.3
  TOP w0.121: U28.4 22.77,111.39 22.39,111.77 22.39,112.18 R460.1
AM335X_MMC2_D0: length 126.3
  TOP w0.121: U28.6 21.77,110.89 20.42,112.24 20.42,113.95 v1(20.81,114.34)
  LY3 w0.133: v1(20.81,114.34) 21.24,114.76 24.25,114.76 24.4,114.62 25.18,114.62 25.48,114.32 34.94,114.32 39.81,119.18 51.58,119.18 53.07,120.67 68.93,120.67 69.06,120.55 69.06,119.7 69.18,119.58 70.47,119.58 70.6,119.7 70.6,120.55 70.73,120.67 71.61,120.67 71.74,120.55 71.74,119.7 71.87,119.58 73.04,119.58 73.16,119.7 73.16,120.55 73.29,120.67 74.05,120.67 75.27,121.9 81.73,121.9 82.49,121.14 105.55,121.14 105.62,121.07 105.74,121.07 v1(106.23,120.58)
  BOTTOM w0.121: v1(106.23,120.58) 106.82,120.58 107.41,119.99 107.41,117.79 106.7,117.09 106.7,96.48 105.58,95.35 104.55,95.35 R456.1
AM335X_MMC2_D1: length 126.6
  TOP w0.121: U28.7 21.05,111.05 20.05,112.05 v1(20.05,114.36)
  LY3 w0.133: v1(107.74,120.28) 107.73,120.28 106.61,121.4 83.52,121.4 82.65,122.28 74.92,122.28 74.54,121.9 70.88,121.9 70.58,121.6 70.57,121.6 70.27,121.3 68.39,121.3 68.11,121.58 67.54,121.58 66.9,120.93 52.96,120.93 51.47,119.44 39.7,119.44 34.84,114.58 25.59,114.58 25.25,114.92 24.5,114.92 24.33,115.1 20.79,115.1 v1(20.05,114.36)
  BOTTOM w0.121: R457.1 103.53,95.11 105.68,95.11 106.95,96.38 106.95,116.99 107.74,117.77 v1(107.74,120.28)
AM335X_MMC2_D2: length 126.1
  TOP w0.121: v1(25.06,114.08) 24.93,113.96 24.93,111.67 24.27,111.02 U28.1
  LY3 w0.133: v1(25.06,114.08) 25.11,114.08 25.31,113.88 34.87,113.88 39.91,118.92 51.69,118.92 53.18,120.41 68.67,120.41 68.79,120.29 68.79,119.98 68.67,119.85 63.77,119.85 63.64,119.72 63.64,119.44 63.77,119.32 73.24,119.32 75.39,121.46 81.72,121.46 82.48,120.7 87.81,120.7 87.99,120.88 105.22,120.88 105.98,120.13 106.64,120.13 v1(106.96,119.8)
  BOTTOM w0.121: v1(106.96,119.8) 107.16,119.61 107.16,117.89 106.46,117.19 106.46,97 R458.1
AM335X_MMC2_D3: length 2.2
  TOP w0.121: U28.3 23.27,111.84 23.91,112.48 R491.1
AM335X_MMC_CLK: length 64.9
  TOP w0.102: 82.65,92.9 82.65,91.35 U2.G17
  TOP w0.121: 82.65,92.9 82.65,93.59 83.16,94.1 83.16,94.12 83.21,94.16 83.21,95.53 82.82,95.92 v1(82.82,96)
  BOTTOM w0.121: R197.2 82.71,142.66 82.71,136.31 83.56,135.47 83.56,135.22 83.43,135.1 82.81,135.1 82.69,134.98 82.69,134.74 82.81,134.62 83.43,134.62 83.56,134.5 83.56,134.25 83.43,134.13 82.81,134.13 82.69,134.01 82.69,133.77 82.81,133.65 83.43,133.65 83.56,133.53 83.56,133.29 83.43,133.17 82.81,133.17 82.69,133.05 82.69,132.81 82.81,132.69 83.43,132.69 83.56,132.56 83.56,132.32 83.43,132.2 82.81,132.2 82.69,132.08 82.69,131.84 82.81,131.72 83.43,131.72 83.56,131.6 83.56,131.36 83.43,131.24 82.81,131.24 82.69,131.12 82.69,130.88 82.81,130.75 83.43,130.75 83.56,130.63 83.56,130.39 83.43,130.27 82.81,130.27 82.69,130.15 82.69,129.91 82.81,129.79 83.43,129.79 83.56,129.67 83.56,122.04 82.01,120.49 82.01,120.02 80.76,118.76 80.75,118.7 80.75,118.49 80.76,118.49 80.76,106.67 80.95,106.48 81.4,106.03 81.4,101.14 81.73,100.81 81.73,99.54 82.89,98.38 83.07,98.2 83.07,97.6 83.22,97.45 83.22,97.24 83.22,96.71 82.82,96.31 v1(82.82,96)
AM335X_MMC_CMD: length 78.7
  TOP w0.102: U2.G18 83,92.9
  TOP w0.121: v1(81.95,143.55) 82.39,143.55 82.52,143.67 85.27,143.67 85.42,143.52 v1(85.86,143.52) ; 83,92.9 83,93.31 v1(83.1,93.41)
  BOTTOM w0.121: v1(85.86,143.52) 85.86,141.72 87.39,140.19 87.39,134.23 88.88,132.73 90.09,132.73 90.21,132.61 90.21,132.37 90.09,132.25 88.88,132.25 88.76,132.13 88.76,131.89 88.88,131.77 90.09,131.77 90.21,131.65 90.21,131.41 90.09,131.29 88.88,131.29 88.76,131.16 88.76,130.92 88.88,130.8 90.09,130.8 90.21,130.68 90.21,130.44 90.09,130.32 88.88,130.32 88.76,130.2 88.76,129.96 88.88,129.84 90.09,129.84 90.21,129.72 90.21,129.48 90.09,129.35 88.88,129.35 88.76,129.23 88.76,128.99 88.88,128.87 90.09,128.87 90.21,128.75 90.21,128.51 90.09,128.39 88.88,128.39 88.76,128.27 88.76,128.03 88.88,127.91 90.09,127.91 90.21,127.79 90.21,127.55 90.09,127.42 88.88,127.42 88.76,127.3 88.76,127.06 88.88,126.94 90.09,126.94 90.21,126.82 90.21,126.58 90.09,126.46 88.88,126.46 88.76,126.34 88.76,124.19 87.03,122.46 87.03,116.38 87.04,116.37 87.04,116.01 87.03,116 87.03,115.11 86.39,114.46 86.39,103.34 86.38,103.34 85.6,102.56 85.6,102.19 85.79,102 85.79,95.8 83.88,93.89 83.58,93.89 83.1,93.41 v1(83.1,93.41) ; R397.2 v1(81.95,143.55)
AM335X_MMC_D0: length 60.5
  TOP w0.102: v2(82.6,90.6) U2.G16
  BOTTOM w0.102: 82.6,93.8 v2(82.6,90.6)
  BOTTOM w0.121: R204.2 79.15,143.45 79.18,143.42 79.77,143.42 80.36,142.83 80.36,140.81 80.24,140.69 80.24,136.24 81.26,135.22 81.26,133.6 81.63,133.23 82.26,133.23 82.38,133.11 82.38,132.87 82.26,132.75 81.63,132.75 81.51,132.63 81.51,132.38 81.63,132.26 82.26,132.26 82.38,132.14 82.38,131.9 82.26,131.78 81.63,131.78 81.51,131.66 81.51,125.12 81.77,124.85 81.77,122.41 80.5,121.14 80.5,107.03 80.5,106.58 80.85,106.23 81.15,105.92 81.15,101.62 81.15,101.04 81.48,100.71 81.48,99.64 81.48,99.44 82.83,98.1 82.83,97.49 82.97,97.34 82.97,96.84 82.05,95.92 82.05,94.34 82.6,93.8
AM335X_MMC_D1: length 72.8
  TOP w0.102: v2(82.6,89.8) U2.G15
  TOP w0.121: v1(84.82,141.74) 84.44,141.74 84.41,141.77 83.73,141.77 83.31,141.35 82.37,141.35 80.94,142.79 80.16,142.79 80.1,142.85 72.24,142.85 v1(71.64,143.45)
  LY4 w0.133: v1(86.04,102.37) 83.63,104.79 83.63,106.26 81.76,108.13 81.76,113.91 82.16,114.31 v1(82.16,116.12)
  BOTTOM w0.102: 83.32,92.9 83.02,92.59 83.02,90.22 v2(82.6,89.8)
  BOTTOM w0.121: 83.32,92.9 84.26,93.84 84.34,93.84 86.04,95.54 v1(86.04,102.37) ; R400.2 v1(71.64,143.45) ; v1(82.16,116.12) 82.16,117.74 83.58,119.16 83.58,120.81 84.75,121.98 84.75,123.56 85.95,124.76 85.95,128.75 84.93,129.78 84.93,140.11 84.82,140.21 v1(84.82,141.74)
AM335X_MMC_D2: length 89.5
  TOP w0.102: U2.F18 82.4,92 82.4,93.1
  TOP w0.121: v1(79.92,142.4) 78.82,142.4 78.7,142.28 78.7,141.57 78.58,141.45 78.33,141.45 78.21,141.57 78.21,142.28 78.09,142.4 77.85,142.4 77.73,142.28 77.73,141.57 77.61,141.45 77.37,141.45 77.25,141.57 77.25,142.28 77.13,142.4 76.89,142.4 76.77,142.28 76.77,141.57 76.65,141.45 76.4,141.45 76.28,141.57 76.28,142.28 76.16,142.4 75.92,142.4 75.8,142.28 75.8,141.57 75.68,141.45 75.44,141.45 75.32,141.57 75.32,142.28 75.2,142.4 74.96,142.4 74.84,142.28 74.84,141.57 74.71,141.45 74.47,141.45 74.35,141.57 74.35,142.28 74.23,142.4 73.99,142.4 73.87,142.28 73.87,141.57 73.75,141.45 73.51,141.45 73.39,141.57 73.39,142.28 73.27,142.4 73.03,142.4 72.9,142.28 72.9,141.57 72.78,141.45 72.54,141.45 72.42,141.57 72.42,142.28 72.3,142.4 72.06,142.4 71.94,142.28 71.94,141.57 71.82,141.45 71.58,141.45 71.46,141.57 71.46,142.28 71.34,142.4 71.1,142.4 70.97,142.28 70.97,141.57 70.85,141.45 70.61,141.45 70.49,141.57 70.49,142.28 70.37,142.4 69.88,142.4 69.76,142.28 69.76,141.64 69.64,141.52 69.4,141.52 69.28,141.64 69.28,142.28 69.16,142.4 68.92,142.4 68.8,142.28 68.8,141.64 68.68,141.52 68.44,141.52 68.32,141.64 68.32,142.28 68.19,142.4 67.95,142.4 67.83,142.28 67.83,141.64 67.71,141.52 67.47,141.52 67.35,141.64 67.35,142.28 67.23,142.4 67.14,142.4 67.02,142.53 67.02,143.32 67.14,143.45 v1(69.23,143.45) ; v1(82.42,97.09) 82.42,96.47 82.33,96.38 82.33,94.74 82.4,94.66 82.4,93.1
  BOTTOM w0.121: v1(82.42,97.09) 81.44,98.06 81.44,98.71 80.87,99.28 80.87,100.62 80.64,100.85 80.64,105.73 80.01,106.37 80.01,106.83 80.01,107.3 79.38,107.93 79.38,120.78 80.56,121.96 80.56,124.75 81.02,125.21 81.02,129.75 80.37,130.4 80.37,134.77 v1(80.31,134.83) 80.31,135.28 79.67,135.92 79.67,141.25 79.41,141.51 79.41,141.9 v1(79.92,142.4) ; R215.2 v1(69.23,143.45)
AM335X_MMC_D3: length 86.9
  TOP w0.102: U2.F17 82.18,91 81.87,91.31 81.87,91.94 81.89,91.96 81.89,91.97
  TOP w0.121: v1(82.38,97.79) 82.18,97.59 82.18,97.48 81.97,97.27 81.97,94.74 82.16,94.56 82.16,92.24 81.89,91.97 ; v1(66.36,142.94) 66.36,141.9 67.05,141.2 68.75,141.2 68.87,141.08 68.87,140.93 69,140.81 69.24,140.81 69.36,140.93 69.36,141.08 69.48,141.2 69.72,141.2 69.84,141.08 69.84,140.93 69.96,140.81 70.2,140.81 70.32,140.93 70.32,141.08 70.44,141.2 70.68,141.2 70.81,141.08 70.81,140.93 70.93,140.81 71.17,140.81 71.29,140.93 71.29,141.08 71.41,141.2 71.65,141.2 71.77,141.08 71.77,140.93 71.89,140.81 72.13,140.81 72.25,140.93 72.25,141.08 72.37,141.2 72.61,141.2 72.74,141.08 72.74,140.93 72.86,140.81 73.1,140.81 73.22,140.93 73.22,141.08 73.34,141.2 73.58,141.2 73.7,141.08 73.7,140.93 73.82,140.81 74.06,140.81 74.18,140.93 74.18,141.08 74.3,141.2 74.55,141.2 74.67,141.08 74.67,140.93 74.79,140.81 75.03,140.81 75.15,140.93 75.15,141.08 75.27,141.2 75.51,141.2 75.63,141.08 75.63,140.93 75.75,140.81 75.99,140.81 76.11,140.93 76.11,141.08 76.23,141.2 76.48,141.2 76.6,141.08 76.6,140.93 76.72,140.81 76.96,140.81 77.08,140.93 77.08,141.08 77.2,141.2 77.44,141.2 77.56,141.08 77.56,140.93 77.68,140.81 77.92,140.81 78.04,140.93 78.04,141.08 78.16,141.2 78.41,141.2 78.53,141.08 78.53,140.93 78.65,140.81 78.89,140.81 79.01,140.93 79.01,141.08 79.13,141.2 79.41,141.2 79.83,141.62 v1(79.92,141.62)
  BOTTOM w0.121: v1(82.38,97.79) 81.88,98.3 81.88,98.66 81.24,99.3 81.24,99.34 81.24,100.6 81.12,100.72 80.89,100.95 80.89,105.84 80.25,106.47 80.25,106.93 80.25,107.4 79.63,108.03 79.63,109.06 79.75,109.18 80.13,109.18 80.25,109.3 80.25,109.54 80.13,109.66 79.75,109.66 79.63,109.78 79.63,110.03 79.75,110.15 80.13,110.15 80.25,110.27 80.25,110.51 80.13,110.63 79.75,110.63 79.63,110.75 79.63,110.99 79.75,111.11 80.13,111.11 80.25,111.23 80.25,111.47 80.13,111.59 79.75,111.59 79.63,111.71 79.63,111.96 79.75,112.08 80.13,112.08 80.25,112.2 80.25,112.44 80.13,112.56 79.75,112.56 79.63,112.68 79.63,112.92 79.75,113.04 80.13,113.04 80.25,113.16 80.25,113.4 80.13,113.52 79.75,113.52 79.63,113.64 79.63,113.89 79.75,114.01 80.13,114.01 80.25,114.13 80.25,114.37 80.13,114.49 79.75,114.49 79.63,114.61 79.63,114.85 79.75,114.97 80.13,114.97 80.25,115.09 80.25,115.33 80.13,115.45 79.75,115.45 79.63,115.58 79.63,115.82 79.75,115.94 80.13,115.94 80.25,116.06 80.25,116.3 80.13,116.42 79.75,116.42 79.63,116.54 79.63,116.78 79.75,116.9 80.13,116.9 80.25,117.02 80.25,117.26 80.13,117.39 79.75,117.39 79.63,117.51 79.63,117.75 79.75,117.87 80.13,117.87 80.25,117.99 80.25,118.23 80.13,118.35 79.75,118.35 79.63,118.47 79.63,118.71 79.75,118.83 80.13,118.83 80.25,118.95 80.25,119.19 80.13,119.32 79.75,119.32 79.63,119.44 79.63,119.68 79.75,119.8 80.13,119.8 80.25,119.92 80.25,120.16 80.13,120.28 79.75,120.28 79.63,120.4 79.63,120.65 81.26,122.28 81.26,130.02 80.62,130.67 80.62,134.45 80.81,134.65 80.81,135.16 79.99,135.98 79.99,141.55 v1(79.92,141.62) ; v1(66.36,142.94) 66.36,143.29 66.46,143.39 R219.2
AM335X_OSC0_IN: length 20.2
  TOP w0.102: 94.38,85.1 92.78,85.1 92.47,85.4 U2.V10
  TOP w0.121: 94.38,85.1 94.86,85.58 98.45,85.58 99.85,84.18 99.85,82.49 R7.2 101.41,80.94 101.41,80.76 C4.1 106.74,80.15 106.97,79.92 106.97,78.65 Y2.3
AM335X_OSC0_OUT: length 11.4
  TOP w0.121: U2.U11 91.43,86.63 91.91,86.63 92.04,86.76 92.95,86.76 93.37,87.17 94.36,87.17 95.32,86.21 98.78,86.21 100.06,84.93 100.52,84.93 R8.1
AM335X_OSC1_IN: length 15.2
  TOP w0.102: 77.74,81.97 77.97,81.97 U2.A6
  TOP w0.121: 77.74,81.97 77.36,81.6 77.22,81.6 77.2,81.63 76.43,81.63 76.42,81.64 76.01,81.64 75.69,81.32 73.32,81.32 72.66,80.66 71.35,80.66 71.12,80.43 68.83,80.43 68.46,80.8 67.45,80.8 67.42,80.77 C2.2 66.71,80.74 65.86,79.9 65.71,79.9 64.93,79.11 Y1.4
AM335X_OSC1_OUT: length 8.5
  TOP w0.102: U2.A4 77.91,80.89 77.1,80.89
  TOP w0.121: 77.1,80.89 76.32,80.89 75.34,79.91 71.66,79.91 71.27,79.53 70.95,79.53 70.84,79.41 R5.1
AM335X_PORZ: length 19.9
  TOP w0.102: U2.B15 79,89.41 78.54,89.87 78.06,89.87
  TOP w0.121: R9.2 69.57,101.76 v1(70.52,100.81) ; v1(76.36,90.53) 76.67,90.22 76.99,90.22 77.33,89.87 78.06,89.87
  BOTTOM w0.121: v1(70.52,100.81) 71.47,99.86 71.47,98.59 71.86,98.21 72.55,98.21 73.19,97.57 73.19,94.22 74.33,93.08 74.33,92.37 75.73,90.97 75.92,90.97 v1(76.36,90.53)
AM335X_RTC_PORZ: length 43.3
  TOP w0.102: 76.32,81.39 77.49,81.39 77.86,81.76 78.65,81.76 79,81.41 U2.B5
  TOP w0.121: 76.32,81.39 76.12,81.39 75.79,81.06 73.44,81.06 72.79,80.41 71.45,80.41 71.22,80.17 68.73,80.17 68.55,80.36 v1(68.11,80.36) ; U1.3 60.48,99.86 v1(60.24,100.11) 60.48,100.36 U1.2
  LY3 w0.133: v1(68.11,80.36) 62.21,80.36 61.93,80.64 v1(61.93,80.68)
  BOTTOM w0.121: R4.2 60.74,100.62 v1(60.24,100.11) 60.24,99.72 59.79,99.28 59.79,97.79 60.08,97.5 60.08,95.26 59.3,94.48 59.3,93.56 59.3,93.56 59.3,92.27 59.22,92.18 59.22,89.66 59.22,89.05 60.36,87.91 60.36,87.52 60.36,87.52 60.36,86.91 61.08,86.18 61.08,83.28 61.71,82.64 61.71,80.9 v1(61.93,80.68)
AM335X_SPI0_CS0: length 106.8
  TOP w0.102: v2(77.3,90.46) 77.48,90.28 78.12,90.28 U2.A16
  TOP w0.121: R313.2 131.36,95.29 v1(131.86,95.8)
  LY3 w0.133: v1(119.82,108.7) 119.52,109 119.52,109.97 119.1,110.39 118.72,110.39 118.63,110.3 108.98,110.3 108.04,111.24 101.08,111.24 100.27,112.04 90.57,112.04 89.6,113.01 87.59,113.01 87.34,113.26 86.97,113.26 86.68,112.97 77.84,112.97 77.3,112.43 v1(69.86,112.43)
  BOTTOM w0.102: v2(77.3,90.46) 77.13,90.46 77.1,90.44
  BOTTOM w0.121: v1(69.86,112.43) 69.86,111.49 69.69,111.31 69.69,106.48 70.38,105.79 70.38,103.85 70.01,103.48 70.01,100.49 71.06,99.45 71.06,99.05 71.09,99.03 71.09,98.66 71.07,98.64 71.81,97.91 72.51,97.91 72.94,97.48 72.94,96.94 R552.1 72.68,95.67 72.68,94.02 72.69,94 72.69,93.96 73.83,92.82 73.83,91.98 75.73,90.08 76.75,90.08 77.1,90.44 ; v1(119.82,108.7) 120.36,108.7 120.63,108.43 120.63,97.56 122.83,95.36 130.41,95.36 130.85,95.8 v1(131.86,95.8)
AM335X_SPI0_CS1: length 10.4
  TOP w0.102: v2(79.4,89.8) U2.C15
  TOP w0.121: R208.1 71.33,92.19 72.29,92.19 R380.2 72.3,92.13 72.61,91.82 72.61,91.56 73.02,91.16 73.02,90.84 v1(73.01,90.83)
  BOTTOM w0.102: 77.1,89.72 79.32,89.72 v2(79.4,89.8)
  BOTTOM w0.121: 77.1,89.72 73.73,89.72 73.01,90.44 v1(73.01,90.83)
AM335X_SPI0_D0: length 106.7
  TOP w0.102: 77.1,91.35 78.65,91.35 U2.B17
  TOP w0.121: R436.1 79.67,133.77 79.79,133.64 81.26,133.64 81.39,133.51 81.39,133.23 80.02,131.86 74.27,131.86 74.08,132.05 74.08,132.24 74.27,132.43 79.09,132.43 79.22,132.56 79.22,133.64 79.09,133.77 78.05,133.77 77.93,133.65 77.93,132.9 77.81,132.78 77.57,132.78 77.45,132.9 77.45,133.65 77.33,133.77 77.08,133.77 76.96,133.65 76.96,132.9 76.84,132.78 76.6,132.78 76.48,132.9 76.48,133.65 76.36,133.77 75.04,133.77 74.92,133.64 74.92,133.39 74.79,133.26 v1(74.36,133.26) ; 77.1,91.35 76.82,91.63 75.01,91.63 74.33,92.3 74.33,94.69 v1(73.88,95.13)
  BOTTOM w0.121: v1(73.88,95.13) 73.88,96.93 74.52,97.57 74.52,97.84 76.1,99.42 76.1,103.29 75.98,103.42 75.98,106.8 76.1,106.92 77.07,106.92 77.19,107.04 77.19,107.28 77.07,107.41 76.1,107.41 75.98,107.53 75.98,107.77 76.1,107.89 77.07,107.89 77.19,108.01 77.19,108.25 77.07,108.37 76.1,108.37 75.98,108.49 75.98,108.93 76.1,109.05 76.97,109.05 77.09,109.17 77.09,109.41 76.97,109.53 76.1,109.53 75.98,109.65 75.98,109.9 76.1,110.02 76.97,110.02 77.09,110.14 77.09,110.38 76.97,110.5 76.1,110.5 75.98,110.62 75.98,110.86 76.1,110.98 76.97,110.98 77.09,111.1 77.09,111.34 76.97,111.46 76.1,111.46 75.98,111.58 75.98,111.83 76.1,111.95 76.97,111.95 77.09,112.07 77.09,112.31 76.97,112.43 76.1,112.43 75.98,112.55 75.98,112.79 76.1,112.91 76.97,112.91 77.09,113.03 77.09,113.27 76.97,113.39 76.1,113.39 75.98,113.52 75.98,113.76 76.1,113.88 76.97,113.88 77.09,114 77.09,114.24 76.97,114.36 76.1,114.36 75.98,114.48 75.98,114.72 76.1,114.84 76.97,114.84 77.09,114.96 77.09,115.2 76.97,115.32 76.1,115.32 75.98,115.45 75.98,115.69 76.1,115.81 76.97,115.81 77.09,115.93 77.09,116.17 76.97,116.29 76.1,116.29 75.98,116.41 75.98,116.65 76.1,116.77 76.97,116.77 77.09,116.89 77.09,117.13 76.97,117.26 76.1,117.26 75.98,117.38 75.98,118.23 76.1,118.35 76.75,118.35 76.87,118.47 76.87,118.71 76.75,118.83 76.1,118.83 75.98,118.95 75.98,119.84 75.29,120.53 75.29,120.63 73.5,122.42 73.5,129.65 73.37,129.77 72.68,129.77 72.55,129.9 72.55,130.55 72.68,130.67 74.6,130.67 74.72,130.79 74.72,131.04 74.6,131.16 71.89,131.16 71.77,131.28 71.77,131.51 71.89,131.64 74.6,131.64 74.72,131.76 74.72,132 74.6,132.12 73.93,132.12 73.81,132.24 73.81,132.71 v1(74.36,133.26)
AM335X_SPI0_D1: length 15
  TOP w0.102: 77.83,90.85 78.1,90.59 78.61,90.59 U2.B16
  TOP w0.121: 77.83,90.85 76.89,90.85 76.62,91.13 74.8,91.13 73.32,92.62 73.06,92.62 v1(72.81,92.87) 72.37,93.32 71.99,93.32 71.54,93.76 R177.1
  BOTTOM w0.121: R553.1 71.03,96.03 71.72,95.34 71.72,93.96 v1(72.81,92.87)
AM335X_SPI0_SCLK: length 8
  TOP w0.102: 78.02,91 U2.A17
  TOP w0.121: R438.1 72.06,93.75 72.07,93.75 72.19,93.63 72.66,93.63 72.97,93.32 72.99,93.32 73.25,93.06 73.25,93.04 74.9,91.38 76.72,91.38 77,91.1 77.92,91.1 78.02,91
AM335X_UART0_CTSN: length 13.6
  TOP w0.102: U2.E18 81.91,92.31 81.91,92.9
  TOP w0.121: R61.2 79.29,103.16 79.29,102.4 81.94,99.74 81.94,97.7 81.73,97.48 81.73,94.64 81.91,94.45 81.91,92.9
AM335X_UART0_RTSN: length 10.8
  TOP w0.102: 81.65,92.9 81.65,92.57 81.06,91.99 81.06,91.35 81.4,91.01 U2.E17
  TOP w0.121: 81.65,92.9 81.65,94.36 81.48,94.53 81.48,97.27 81.48,97.65 81.66,97.83 81.66,97.83 81.69,97.87 81.69,98.87 81.34,99.23 80.17,99.23 R362.2
AM335X_UART0_RXD: length 104.9
  TOP w0.102: v2(81,89.8) U2.E15
  TOP w0.121: v1(78.64,105.46) 78.02,104.84 77.81,104.84 77.4,104.44 77.4,103.47 78.4,102.48 78.4,100.2 78.15,99.95 78.15,99.52 78.57,99.1 79.54,99.1 80.17,98.46 R220.1 80.2,98.08 80.62,97.66 80.91,97.66 81.23,97.34 81.23,97.17 81.23,94.53 81.18,94.48 v1(81.18,94.04) ; v1(52.23,63.41) R249.2
  LY3 w0.133: v1(78.64,105.46) 77.56,106.54 54.52,106.54 53.17,107.89 51.9,107.89 51.87,107.85 51.74,107.85 51.48,107.59 51.48,107.46 v1(51.14,107.12)
  BOTTOM w0.102: v2(81,89.8) 81,89.83 80.58,90.24 80.58,90.97
  BOTTOM w0.121: v1(51.14,107.12) 47.43,107.12 44.84,104.53 44.84,103.38 44.81,103.35 44.81,98.78 44.64,98.61 44.64,94.02 45.12,93.53 45.12,80.81 44.35,80.04 43.12,78.8 43.12,71.87 48.02,66.97 51.22,66.97 52.23,65.95 v1(52.23,63.41) ; v1(81.18,94.04) 81.14,94.04 80.54,93.45 80.54,91.01 80.58,90.97
AM335X_UART0_TXD: length 15.9
  TOP w0.102: v2(81,90.6) U2.E16
  TOP w0.121: v1(79,96.27) 78.7,96.57 73.31,96.57 R361.2
  BOTTOM w0.102: 80.79,92.9 80.79,92.36 81,92.15 v2(81,90.6)
  BOTTOM w0.121: 80.79,92.9 80.79,93.31 81.06,93.59 81.42,93.59 81.62,93.79 81.62,95.46 80.76,96.33 79.05,96.33 v1(79,96.27)
AM335X_UART1_CTSN: length 17.9
  TOP w0.102: U2.D18 80.74,91.94
  TOP w0.121: v1(80.79,96.99) 80.79,96.73 80.98,96.53 80.98,94.75 80.74,94.51 80.74,91.94 ; v1(76.56,103.54) 76.56,103.54 75.86,103.54 R445.1
  BOTTOM w0.121: v1(76.56,103.54) 78.12,103.54 79.46,102.2 79.46,101.15 78.93,100.62 78.9,100.62 79.45,100.08 79.45,96.83 79.71,96.57 80.37,96.57 80.78,96.99 v1(80.79,96.99)
AM335X_UART1_RTSN: length 17.7
  TOP w0.102: 80.24,91.92 80.24,91.35 80.59,91 U2.D17
  TOP w0.121: 80.24,91.92 80.49,92.17 80.49,94.69 80.74,94.93 80.74,96.41 80.34,96.81 80.34,97.3 80.14,97.51 77.57,97.51 76.74,98.34 76.74,99.99 R229.1 76.75,101 76.75,102.17 v1(76.54,102.37)
  BOTTOM w0.121: 77.76,100.62 77.61,100.62 76.9,101.33 76.9,101.99 76.54,102.35 v1(76.54,102.37)
AM335X_UART1_RXD: length 15.5
  TOP w0.102: v2(80.2,90.6) U2.D16
  TOP w0.121: R356.1 73.19,99.23 74.34,99.23 74.59,99.48 75.48,99.48 76.36,98.59 76.36,98.37 77.47,97.26 79.01,97.26 79.88,96.39 v1(79.88,95.88)
  BOTTOM w0.102: v2(80.2,90.6) 80.2,90.97 80.29,91.06 80.29,93.51
  BOTTOM w0.121: 80.29,93.51 80.29,95.47 v1(79.88,95.88)
AM335X_UART1_TXD: length 12.7
  TOP w0.102: v2(80.2,89.8) U2.D15
  TOP w0.121: R236.1 75.34,96.81 79.11,96.81 79.44,96.48 79.44,95.7 79.85,95.29 v1(79.85,95.16)
  BOTTOM w0.102: v2(80.2,89.8) 79.98,90.02 79.98,90.04 79.78,90.25 79.78,90.43
  BOTTOM w0.121: v1(79.85,95.16) 79.85,94.68 80.05,94.49 80.05,91.12 79.99,91.06 79.99,91.04 79.79,90.84 79.79,90.44 79.78,90.43
AM335X_USB0_CE: length 13.8
  TOP w0.102: v2(87.4,89.8) U2.M15
  TOP w0.121: TP23.1 93.14,98.59 93.64,99.09 v1(93.64,99.1)
  LY3 w0.133: v1(93.64,99.1) 93.38,98.84 92.24,98.84 89.57,96.18 89.57,95.13 87.86,93.42 87.86,90.82 87.8,90.76 87.8,90.46 87.8,90.46 87.8,90.21 87.4,89.81 v2(87.4,89.8)
AM335X_USB0_DRVVBUS: length 106.2
  TOP w0.102: U2.F16 v2(81.8,90.6)
  TOP w0.121: v1(138.42,144.6) 137.87,145.15 U22.4
  LY3 w0.133: v1(86.4,133.83) 94.59,133.83 101.51,140.75 118.66,140.75 121.45,143.55 137.36,143.55 v1(138.42,144.6)
  LY4 w0.133: v1(86.4,133.83) 86.21,133.83 85.06,132.69 85.06,130.59 83.98,129.51 83.98,119.65 83.07,118.73 82.49,118.73 81.33,117.58 81.33,98.31 81.26,98.24 81.26,97.34 81.33,97.27 81.33,95.18 80.49,94.33 80.49,92.77 80.73,92.52 80.73,92.52 80.96,92.29 80.97,92.29 81.8,91.45 v2(81.8,90.6)
  BOTTOM w0.121: R383.1 137.35,144.6 v1(138.42,144.6)
AM335X_USB0_VBUS: length 17.6
  TOP w0.254: v2(89,89.8) U2.P15 ; D9.1 96.3,96.24 R563.2
  TOP w0.508: R563.2 95.99,97.05 v1(94.84,97.05)
  LY3 w0.127: 89.01,91.27 89.41,90.88 89.41,90.21 v2(89,89.8)
  LY3 w0.133: v2(89,89.8) 88.6,90.2 88.6,90.86 89.01,91.27
  LY3 w0.508: v1(94.84,97.05) 94.39,97.5 92.47,97.5 91.99,97.01 91.99,96.13 90.64,94.78 90,94.78 89.01,93.79 89.01,91.27
AM335X_USB1_CE: length 6.2
  TOP w0.102: 88.6,92.9 U2.P18
  TOP w0.121: 88.6,92.9 88.6,93.55 89.56,94.52 90.45,94.52 91.35,95.41 TP36.1
AM335X_USB1_DRVVBUS: length 133.6
  TOP w0.102: U2.F15 v2(81.8,89.8)
  TOP w0.121: U29.4 v1(146.58,144.83)
  LY3 w0.133: v1(85.57,133.9) 86.21,133.26 94.65,133.26 101.76,140.37 118.91,140.37 121.7,143.17 138.85,143.17 142.53,139.48 142.53,133.77 v1(143.36,132.94)
  LY4 w0.133: v2(81.8,89.8) 81.4,90.2 81.4,90.76 81.41,90.77 81.41,91.48 79.98,92.9 79.98,94.53 80.34,94.88 80.34,98.43 79.98,98.78 79.98,104.5 80.56,105.07 80.56,117.55 82.49,119.49 82.49,120.53 83.54,121.57 83.54,131.86 v1(85.57,133.9)
  BOTTOM w0.121: R387.1 146.21,145.2 v1(146.58,144.83) 146.58,143.09 146.34,142.85 145.33,142.85 145.01,142.53 145.01,137.51 143.42,135.93 143.42,133.01 v1(143.36,132.94)
AM335X_USB1_VBUS: length 13.7
  TOP w0.254: v1(89.85,101.74) 90.4,101.19 D10.1 ; U2.T18 v2(90.2,92.37)
  TOP w0.508: R564.2 90.28,102.95 90.08,102.75 90.08,101.97 v1(89.85,101.74)
  LY4 w0.508: v2(90.2,92.37) 90.51,92.37 91.27,93.13 91.27,95.87 90.66,96.48 90.66,100.93 v1(89.85,101.74)
AM335X_VDDA_ADC: length 42.7
  TOP w0.381: v2(80.2,83.4) U2.D8
  TOP w0.508: v1(49.31,74.43) v1(59,74.43) ; v1(76.82,82.08) 76.64,82.08 76.58,82.14 73.32,82.14 72.27,81.1 71.02,81.1 70.79,80.87 70.26,80.87 70.26,80.87 70.21,80.87 69.29,81.79 66.12,81.79 66.03,81.7 65.8,81.46 64.49,81.46 64.38,81.57 60.28,81.57 60.17,81.68 v1(59.54,81.68)
  BOTTOM w0.152: v1(76.82,82.08) 77.19,82.08 77.82,82.71 79.67,82.71 80.2,83.25 v2(80.2,83.4)
  BOTTOM w0.508: 50.33,74.71 49.6,74.71 v1(49.31,74.43) R501.1 ; v1(59.54,81.68) 59.52,81.66 59.52,79.7 59.54,79.68 59.54,74.97 v1(59,74.43)
AM335X_VDDS: length 40.2
  TOP w0.305: v2(81,81.8) U2.E6
  TOP w0.381: v2(89,84.2) U2.P9 ; v2(89,89) U2.P14 ; v2(82.6,84.2) U2.F9 ; U2.E14 v2(81,89) ; v2(88.2,81.8) U2.N6 ; v2(85.8,88.2) U2.K13
  TOP w0.635: v1(99.99,111.54) 99.1,111.54 97.69,110.14 94.44,110.14 93.18,108.88 v1(88.21,108.88)
  LY4 w0.635: v1(87.83,98.59) 87.83,99.29 88.21,99.66 v1(88.21,108.88)
  BOTTOM w0.102: v2(81,89) 81,89.26 81.42,89.68 81.42,90.21 ; 81.42,90.21 81.42,91.07 C96.1 82.21,91.1 82.21,90.33 82.08,90.21 81.42,90.21
  BOTTOM w0.508: C48.1 92.45,90.52 v1(92.9,90.08) 92.77,89.95 92.71,89.95 92.43,89.68 C50.1
  BOTTOM w0.635: R498.1 100.75,115.32 C89.1 100.37,112.56 100.37,111.92 v1(99.99,111.54) 99.99,110.43 C249.1
  vias: v1(93.64,90.21)
AM335X_VDDS_DDR: length 54.2
  TOP w0.381: U2.L5 v2(85.8,81) U2.K5 ; U2.H5 v2(84.2,81) U2.J5 ; v2(82.6,81) U2.G5 ; U2.E5 v2(81.8,81) U2.F5
  TOP w0.635: v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13) 98.74,73.13 98.99,72.87 101.75,72.87 103.95,70.67 103.95,68.92 104.44,68.43 104.73,68.43 C233.1 108.24,67.71 110.78,65.17 110.78,65.06 115.6,65.06 116.29,65.75 116.29,68.85 115.7,69.44 R508.2
  LY3 w0.635: v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13)
  LY4 w0.635: 92.34,82.38 92.65,82.08 93.54,82.08 94.02,81.6 94.02,80.56 94.53,80.05 94.53,77.76 96.43,75.86 v1(96.43,73.13) v1(97.04,73.13) v1(97.62,73.13)
  BOTTOM w0.381: v2(81.8,81) 81.76,81.04 C77.1 ; v1(96.43,73.13) 96.31,73 95.61,73 C80.1 ; C82.1 v1(97.62,73.13) ; v2(82.6,81) 83.3,81.7 C76.1 ; C79.1 84.26,80.94 v2(84.2,81) ; v2(85.8,81) 85.86,80.94 C78.1
  BOTTOM w0.635: v1(97.62,73.13) v1(97.04,73.13) v1(96.43,73.13)
AM335X_VDDSHV1: length 54
  TOP w0.381: U2.P8 v2(89,83.4) U2.P7
  LY3 w0.102: 91.29,82.98 89.69,82.98 89.65,83.02 89.64,83.02 89.26,83.4 v2(89,83.4) 89,82.65 89.45,82.21 91.43,82.21 91.74,82.52
  LY3 w0.508: 91.29,82.98 92.06,82.21 95.67,82.21 98.34,79.54 99.16,79.54 99.8,80.17 v1(99.99,80.17) 100.62,80.81 100.62,81.95 101.38,82.71 v1(102.91,82.71) 103.54,83.35 107.1,83.35 v1(108.37,82.08)
  BOTTOM w0.381: v2(89,83.4) 88.31,83.4 C31.1
  BOTTOM w0.508: R493.1 122.11,73.54 120.69,74.97 115.48,74.97 v1(108.37,82.08) ; v1(102.91,82.71) 103.8,82.71 C32.1 ; C258.1 101.65,79.4 101.38,79.67 100.49,79.67 v1(99.99,80.17)
AM335X_VDDSHV2: length 39.3
  TOP w0.381: U2.P10 88.6,85.46 88.72,85.58 88.72,86.02 88.6,86.14 U2.P11 v2(89,86.6)
  TOP w0.508: C92.1 95.85,87.59 v1(95.85,86.7) 97.89,86.7 C259.1
  LY3 w0.635: v2(89,86.6) 89.15,86.45 89.15,86.33 89.68,85.8 91.99,85.8 92.54,86.35 93,86.35 93.69,87.04 94.73,87.04 95.07,86.7 v1(95.85,86.7) 96.87,87.73 99.11,87.73 101.12,89.74 101.12,91.54 102.4,92.82 108.29,92.82 110.5,95.03 v1(115.42,95.03)
  BOTTOM w0.381: C90.1 89,85.95 v2(89,86.6)
  BOTTOM w0.635: R545.1 114.43,95.03 v1(115.42,95.03)
AM335X_VDDSHV3: length 97.8
  TOP w0.381: U2.P12 v2(89,87.4) ; v2(89,88.2) U2.P13
  TOP w0.635: R546.1 v1(135,140.59)
  LY3 w0.635: v1(108.85,95.01) 107.65,93.81 102.54,93.81 v1(102.31,93.59) 101.87,93.59 100.9,92.62 100.37,92.62 99.54,91.79 97.94,91.79 97.14,90.99 97.14,89.66 96.57,89.09 96.14,89.09 v1(95.99,88.94) 94.97,87.92 93.28,87.92 93.24,87.97 93.17,87.97 ; v1(110.65,135.93) 132.24,135.93 134.4,138.09 134.4,139.99 v1(135,140.59)
  LY4 w0.635: v1(108.85,95.01) 110.55,96.71 110.55,100.16 111.54,101.15 111.54,103.92 109.89,105.57 109.89,135.17 v1(110.65,135.93)
  BOTTOM w0.381: C94.1 88.28,88.2 v2(89,88.2) v2(89,87.4)
  BOTTOM w0.508: C273.1 102.85,93.59 v1(102.31,93.59) ; v1(95.99,88.94) 95.99,88.94 96.84,88.94 97.19,89.29 C93.1
AM335X_VDDSHV4: length 104.9
  TOP w0.381: U2.J14 v2(84.2,89) U2.H14
  TOP w0.635: v1(133.58,133.07) 131.1,133.07 130.47,133.7 v1(122.47,133.7)
  LY3 w0.635: v1(84.16,114.59) 84.38,114.81 84.9,114.81 84.93,114.78 116.24,114.78 v1(119.42,111.61)
  LY4 w0.635: v1(84.15,95.39) 84.15,95.34 84.39,95.1 85.01,95.1 86.14,93.97 86.14,92.32 84.92,91.1 84.92,89.39 84.53,89 v2(84.2,89)
  BOTTOM w0.635: C43.1 83.6,94.58 84.15,95.12 v1(84.15,95.39) 84.15,95.83 84.82,96.51 C274.1 84.01,97.51 83.92,97.51 83.58,97.86 83.58,98.41 83.17,98.82 83.17,113.6 v1(84.16,114.59) ; C42.1 84.07,89.13 v2(84.2,89) ; R494.1 134.69,133.07 v1(133.58,133.07) ; v1(119.42,111.61) 119.73,111.92 119.73,129.64 122.47,132.37 v1(122.47,133.7)
AM335X_VDDSHV5: length 74.6
  TOP w0.381: U2.K14 v2(85.8,89) U2.L14
  TOP w0.635: v1(98.34,130.09) 96.43,130.09 96.04,130.47 91.33,130.47 v1(91.24,130.57)
  LY4 w0.102: v2(85.8,89) 85.8,89.03 85.42,89.41 85.42,90.82 85.74,91.13 86.18,91.13 86.18,89.38 v2(85.8,89) ; v2(85.8,89) 86.71,89 86.98,89.27 86.98,90.76 86.97,90.77 86.97,91.48
  LY4 w0.508: v1(88.81,96.25) 88.81,95.16 88.68,95.03 88.68,93.19 86.97,91.48 86.52,91.48 86.18,91.13
  BOTTOM w0.635: R495.1 99.35,141.26 98.72,140.63 98.72,132.9 98.65,132.84 98.65,130.4 v1(98.34,130.09) ; C46.1 85.94,89.14 v2(85.8,89) ; v1(91.24,130.57) 91.24,130.48 90.92,130.16 90.92,120.78 91.95,119.75 91.95,114.9 90.59,113.54 90.59,108.39 91.79,107.19 91.79,104.42 90.42,103.05 C257.1 90.59,102.8 90.59,100.68 90.14,100.24 90.14,98.53 89.06,97.45 C45.1 89.06,96.51 v1(88.81,96.25)
AM335X_VDDSHV6: length 15.7
  TOP w0.381: U2.P5 v2(88.2,81) U2.N5 ; U2.P5 v2(89,81) ; U2.P5 v2(89,81.8) U2.P6 ; U2.E10 v2(81,85.8) U2.E11 v2(81,86.6) U2.E12 ; U2.F14 v2(82.6,89) U2.G14 ; U2.E13 v2(81,88.2)
  TOP w0.635: v1(50.31,85.07) 50.33,85.05 C28.1
  BOTTOM w0.381: v1(69.76,83.1) 70.14,83.48 70.9,83.48 ; C47.1 79.03,91.73 v2(78.52,92.24)
  BOTTOM w0.635: v2(82.6,89) 82.47,89.13 C27.1 ; C247.1 51.51,85.07 v1(50.31,85.07) 50.31,86.85 R496.1 ; v2(92.91,79.51) 93.1,79.51 93.31,79.29 93.69,79.29 C29.1 ; v2(92.37,81.37) 92.37,81.57 92.24,81.69 C25.1
AM335X_XDMA_EVENT_INTR0: length 16.1
  TOP w0.102: U2.A15 77.45,89.4 77.1,89.75
  TOP w0.121: v1(73.92,91.08) 74.36,91.08 74.56,90.89 75.08,90.89 76.06,89.91 76.94,89.91 77.1,89.75 ; R349.1 67.09,95.03 TP31.1 68.49,95.86 68.62,95.98 68.99,95.98 69.41,95.56 69.42,95.56 69.44,95.54 70.18,95.54 70.67,95.06 v1(71.03,95.06)
  BOTTOM w0.121: v1(71.03,95.06) 71.03,93.56 71.24,93.35 71.24,92.76 71.81,92.19 73.24,92.19 73.5,91.93 73.5,91.47 73.89,91.08 v1(73.92,91.08)
AM335X_XDMA_EVENT_INTR1: length 32.3
  TOP w0.102: v2(80.2,89) U2.D14
  TOP w0.121: R77.2 63.73,92.3 v1(63.66,92.3) 63.09,92.87 TP32.1
  LY3 w0.133: v1(75.98,98.08) 74.71,96.81 64.55,96.81 v1(63.54,95.8)
  BOTTOM w0.102: 77.51,92.9 77.51,91.1 77.89,90.72 77.89,90.21 78.14,89.95 78.9,89.95 79.16,90.21 79.51,90.21 79.52,90.22 79.78,89.96 79.78,89.58 80.2,89.16 v2(80.2,89)
  BOTTOM w0.121: v1(63.66,92.3) 63.54,92.43 v1(63.54,95.8) 63.66,95.92 R351.1 ; v1(75.98,98.08) 76.49,97.57 76.49,95.92 77.51,94.91 77.51,92.9
CAP_VBB_MPU: length 4.2
  TOP w0.102: U2.C10 79.41,85.79 v2(79.41,85.8)
  BOTTOM w0.102: 77.22,85.8 v2(79.41,85.8)
  BOTTOM w0.121: C72.1 76.62,86.27 77.09,85.8 77.22,85.8
CAP_VDD_SRAM_CORE: length 12.6
  TOP w0.102: v2(80.2,85) U2.D9
  TOP w0.121: v1(76.59,85.42) 76.59,85.92 75.6,86.91 74.74,86.91 74.55,87.1 72.02,87.1 71.58,86.66 70.01,86.66 C60.1
  BOTTOM w0.102: 77.73,85.2 78.56,85.2 78.74,85.38 79.56,85.38 79.94,85 v2(80.2,85)
  BOTTOM w0.121: v1(76.59,85.42) 77.52,85.42 77.73,85.2
CAP_VDD_SRAM_MPU: length 5.7
  TOP w0.102: v2(80.2,86.6) U2.D11
  BOTTOM w0.102: v2(80.2,86.6) 80.01,86.79 78.26,86.79 77.63,87.42
  BOTTOM w0.121: C71.1 75.85,87.42 77.63,87.42
COM_AUD_CLK: length 2.8
  TOP w0.121: J11.52 4.86,125.64 v1(4.61,125.39)
  BOTTOM w0.121: v1(4.61,125.39) 5.12,124.88 R338.2
COM_AUD_FSYNC: length 2.6
  TOP w0.121: J11.54 v1(4.61,126.28)
  BOTTOM w0.121: v1(4.61,126.28) 5.37,126.28 R339.2
COM_AUD_IN: length 2.6
  TOP w0.121: v1(4.61,127.04) 4.74,126.91 J11.56
  BOTTOM w0.121: R340.2 5.5,127.04 v1(4.61,127.04)
COM_AUD_OUT: length 2.8
  TOP w0.121: v1(4.61,127.8) 4.86,127.55 J11.58
  BOTTOM w0.121: v1(4.61,127.8) 5.12,127.8 R341.2
COM_BTRST: length 6.8
  TOP w0.121: J11.89 17.44,140.88 v1(19.21,139.1)
  BOTTOM w0.121: 20.1,139.1 v1(19.21,139.1)
COM_BTUARTCTS: length 2.8
  TOP w0.121: v1(4.61,134.78) 4.86,134.53 J11.70
  BOTTOM w0.121: R344.2 5.63,134.78 v1(4.61,134.78)
COM_BTUARTDEBUG: length 3
  TOP w0.121: 6.07,136.44 v1(4.61,136.44)
  BOTTOM w0.121: TP45.1 4.48,136.44 v1(4.61,136.44)
COM_BTUARTRTS: length 3
  TOP w0.121: J11.72 5.94,135.29 4.86,135.29 v1(4.61,135.55)
  BOTTOM w0.121: R345.2 5.24,135.55 v1(4.61,135.55)
COM_BTUARTRX: length 2.8
  TOP w0.121: 6.07,133.9 4.74,133.9 v1(4.61,134.02)
  BOTTOM w0.121: v1(4.61,134.02) 5.5,134.02 R343.2
COM_BTUARTTX: length 2.9
  TOP w0.121: J11.66 4.74,133.26 v1(4.61,133.13)
  BOTTOM w0.121: R342.2 5.24,133.13 v1(4.61,133.13)
COM_GNSS_PPS_OUT: length 21.8
  TOP w0.121: v1(7.72,126.15) 7.72,125.57 7.28,125.13 6.2,125.13 J11.50 ; v1(7.66,129.96) 8.32,129.96 8.92,130.56 16.45,130.56 19.35,127.67 19.35,126.92 19.89,126.38 U14.10
  BOTTOM w0.121: v1(7.72,126.15) 8.1,126.53 8.1,129.52 v1(7.66,129.96)
COM_GNSS_TIME_STAMP: length 25.9
  TOP w0.121: J11.48 7.77,124.37 8.79,125.38 8.79,128.29 10.06,129.57 15.79,129.57 17.94,127.42 17.94,124.37 18.71,123.61 18.71,120.43 19.11,120.03 U13.10
COM_SDIO_CLK: length 6.2
  TOP w0.121: J11.20 7.4,115.48 v1(7.66,115.23)
  BOTTOM w0.121: R485.2 R334.1 7.66,113.32 v1(7.66,115.23)
COM_SDIO_CMD: length 5.1
  TOP w0.121: v1(7.66,116.37) 7.28,116.75 J11.24
  BOTTOM w0.121: v1(7.66,116.37) 7.15,115.86 7.15,115.52 6.64,115.02 R333.1 R486.2
COM_SDIO_D0: length 6.2
  TOP w0.121: J11.26 v1(7.66,117.39)
  BOTTOM w0.121: R487.2 R332.1 7.83,116.88 8.14,116.57 8.34,116.57 8.47,116.7 8.47,117.26 8.34,117.39 v1(7.66,117.39)
COM_SDIO_D1: length 5.3
  TOP w0.121: v1(8.42,118.02) J11.28
  BOTTOM w0.121: R488.2 R331.1 6.67,117.99 8.39,117.99 v1(8.42,118.02)
COM_SDIO_D2: length 7.1
  TOP w0.121: 6.07,118.66 v1(7.66,118.66)
  BOTTOM w0.121: v1(7.66,118.66) 7.68,118.68 8.6,118.68 8.72,118.81 8.72,119.33 8.6,119.46 8.31,119.46 8.2,119.35 7.36,119.35 7.23,119.47 7.23,119.72 R489.2 R330.1
COM_SDIO_D3: length 6.4
  TOP w0.121: J11.32 7.3,119.29 v1(7.86,119.85)
  BOTTOM w0.121: v1(7.86,119.85) 7.89,119.87 7.89,121.35 R490.2 R329.1
COM_SLOW_CLK: length 36.2
  TOP w0.121: v1(15.91,109.43) 15.51,109.43 15.18,109.77 J11.1 ; v1(15.91,137.96) 16.1,137.78 U15.12
  BOTTOM w0.121: v1(15.91,109.43) 17.18,110.7 17.18,136.56 15.91,137.83 v1(15.91,137.96)
COM_WL_IRQ: length 8.2
  TOP w0.121: v1(12.48,119.04) 11.21,120.31 7.64,120.31 7.36,120.03 6.16,120.03 6.07,119.94 J11.34
  BOTTOM w0.121: R337.2 v1(12.48,119.04)
COM_WL_RS232_RX: length 3.1
  TOP w0.121: 14.07,113.58 v1(12.23,113.58)
  BOTTOM w0.121: v1(12.23,113.58) TP43.1
COM_WL_RS232_TX: length 2.8
  TOP w0.121: v1(15.66,112.69) 15.4,112.94 J11.11
  BOTTOM w0.121: v1(15.66,112.69) 15.4,112.94 TP42.1
COM_WL_RST: length 3.1
  TOP w0.121: J11.4 4.48,110.4 v1(4.36,110.27)
  BOTTOM w0.121: R327.2 4.61,110.02 v1(4.36,110.27)
COM_WL_UART_DBG: length 2.5
  TOP w0.121: J11.15 v1(15.66,114.21)
  BOTTOM w0.121: v1(15.66,114.21) TP44.1
COMAUD_CLK: length 21.2
  TOP w0.121: U14.13 19.03,124.43 18.33,125.13 18.33,127.64 16.15,129.82 9.8,129.82 8.54,128.55 8.54,125.76 v1(7.66,124.88)
  BOTTOM w0.121: R338.1 v1(7.66,124.88)
COMAUD_FSYNC: length 26.3
  TOP w0.121: v1(8.78,124.75) 9.03,125.01 9.03,128.03 10.32,129.32 15.69,129.32 17.31,127.7 17.31,120.56 18.49,119.38 U13.11
  BOTTOM w0.121: R339.1 7.34,125.32 8.23,125.32 8.78,124.77 v1(8.78,124.75)
COMAUD_IN: length 19
  TOP w0.121: U14.12 19.4,125.08 18.71,125.77 18.71,127.61 16.25,130.06 9.54,130.06 8.29,128.82 8.29,127.67 v1(7.66,127.04)
  BOTTOM w0.121: R340.1 7.53,127.16 v1(7.66,127.04)
COMAUD_OUT: length 17.4
  TOP w0.121: v1(7.66,128.94) 9.03,130.31 16.35,130.31 18.96,127.7 18.96,126.28 19.51,125.73 U14.11
  BOTTOM w0.121: v1(7.66,128.94) 7.02,128.31 R341.1
COMBTRST: length 2.2
  TOP w0.121: v1(21.88,139.1) 21.65,139.08 U15.10
  BOTTOM w0.121: R353.2 v1(21.88,139.1)
COMBTUARTCTS: length 16.4
  TOP w0.121: v1(7.53,134.91) 7.97,134.47 7.97,132.28 8.56,131.69 18.89,131.69 19.16,131.43 U16.12
  BOTTOM w0.121: R344.1 v1(7.53,134.91)
COMBTUARTRTS: length 16.6
  TOP w0.121: U16.10 16.65,132.73 16.11,132.18 11.4,132.18 10.96,132.63 10.96,134.4 9.31,136.05 v1(7.53,136.05)
  BOTTOM w0.121: R345.1 v1(7.53,136.05)
COMBTUARTRX: length 15.8
  TOP w0.121: U16.13 19.09,130.78 18.42,131.44 8.46,131.44 7.53,132.37 v1(7.53,133.77)
  BOTTOM w0.121: R343.1 v1(7.53,133.77)
COMBTUARTTX: length 14.1
  TOP w0.121: U16.11 16.76,132.08 16.62,131.94 9.1,131.94 v1(8.41,132.63)
  BOTTOM w0.121: R342.1 v1(8.41,132.63)
COMWL_IRQ: length 6.7
  TOP w0.121: U13.13 18.73,118.08 17.24,119.57 v1(15.91,119.57)
  BOTTOM w0.121: v1(15.91,119.57) 15.38,119.04 R337.1
COMWL_RST: length 37.1
  TOP w0.121: U15.13 16.22,137.13 v1(15.91,136.82)
  BOTTOM w0.121: R327.1 v1(7.66,110.4) 11.21,113.96 11.21,134.66 13.37,136.82 v1(15.91,136.82)
DDR_A0: length 57.5
  TOP w0.076: U31.H8 v1(93.16,57.44) ; v1(70.94,57.44) U8.H8
  TOP w0.121: v1(85,55.22) 85,56.81 85.64,57.44 85.64,61.91 86.84,63.12 86.84,63.95 86.25,64.54 86.25,66.8 86.25,67.11 83.22,70.14 v1(83.22,70.97)
  BOTTOM w0.076: v1(70.94,57.44) 70.94,57.47 71.51,58.05 73.76,58.05 75.07,56.74 ; 93.62,56.97 v1(93.16,57.44)
  BOTTOM w0.121: v1(83.22,70.97) 81.25,70.97 80.49,71.73 R18.2 ; 75.07,56.74 75.07,56.36 75.14,56.29 75.14,54.77 75.27,54.65 80.81,54.65 81.25,55.09 81.26,55.09 81.39,55.22 v1(85,55.22) 85.44,55.22 85.7,54.96 86.33,54.96 86.46,54.83 86.46,53.5 86.59,53.38 94.08,53.38 94.21,53.5 94.21,56.57 94.08,56.69 93.75,56.69 93.62,56.82 93.62,56.97
DDR_A1: length 70.1
  TOP w0.076: 71.16,60.55 71.34,60.73 U8.H3 ; v1(70.94,61.44) 70.56,61.06 68.71,61.06 68.7,61.04 68.47,61.04 ; v1(93.61,61.25) 93.61,60.82 93.72,60.7 93.72,60.24 93.85,60.11 96.81,60.11 96.94,59.98 96.94,59.73 97.07,59.6 98.21,59.6 98.34,59.73 98.34,60.24 98.21,60.36 94.27,60.36 93.98,60.65 93.98,61.71 93.85,61.84 U31.H3
  TOP w0.121: 71.16,60.55 68.49,60.55 68.36,60.68 68.36,60.93 68.47,61.04 ; v1(87.86,62.39) 87.86,61.79 86.77,60.7 86.5,60.7 86.38,60.83 86.38,61.61 87.63,62.86 87.63,63.21 87.75,63.33 88.01,63.33 88.13,63.45 88.13,63.69 88.01,63.81 87.75,63.81 87.63,63.93 87.63,64.17 87.75,64.29 88.01,64.29 88.13,64.41 88.13,64.65 88.01,64.77 87.75,64.77 87.63,64.9 87.63,65.92 87.44,66.11 87.44,66.75 84.17,70.01 84.17,71.03 R21.2
  BOTTOM w0.076: 77.91,63.28 71.41,63.28 71.35,63.22 71.35,61.85 v1(70.94,61.44) ; 89.24,60.69 89.63,60.3 91.22,60.3 91.35,60.43 91.35,60.68 91.48,60.81 92.49,60.81 92.62,60.68 92.62,60.43 92.75,60.3 94.3,60.3 94.4,60.39 94.4,60.52 94.3,60.62 93.74,60.62 93.61,60.74 v1(93.61,61.25)
  BOTTOM w0.121: 89.24,60.69 89.16,60.77 89.16,60.92 89.04,61.05 89.01,61.05 88.43,61.63 88.43,61.82 88.56,61.95 88.56,62.39 87.73,63.22 87.29,63.22 87.16,63.09 87.16,62.84 87.29,62.71 87.54,62.71 v1(87.86,62.39) 87.86,62.08 87.76,61.98 86.46,61.98 86.33,62.11 86.33,62.39 86.21,62.52 85.16,62.52 84.47,63.21 82.95,63.21 82.65,62.91 80.25,62.91 79.8,62.91 79.43,63.28 77.91,63.28
DDR_A2: length 57.1
  TOP w0.076: v1(93.16,59.04) U31.H7 ; v1(70.94,59.04) U8.H7
  TOP w0.121: v1(84.05,58.39) 84.05,58.84 83.92,58.97 83.79,58.97 83.67,59.1 83.67,60.17 83.79,60.3 83.86,60.3 83.99,60.43 83.99,61.96 84.36,62.34 84.36,62.7 84.11,62.95 84.11,66.11 82.66,67.57 82.66,68 81.26,69.4 80.8,69.4 80.37,69.84 80.37,70.59 80.37,70.6 v1(80.37,70.6)
  BOTTOM w0.076: v1(70.94,59.04) 70.65,59.04 70.52,59.16 70.52,60.49 70.65,60.62 73.79,60.62 74.31,60.1 74.31,59.37 74.52,59.16 77.32,59.16 77.54,58.94 77.67,58.8 77.79,58.8 77.81,58.78 77.91,58.78 ; 89.24,57 89.64,57 89.89,57.25 89.89,58.9 90.02,59.03 90.72,59.03 90.84,58.9 90.84,58.33 90.97,58.2 91.6,58.2 91.73,58.33 91.73,58.46 91.86,58.58 92.05,58.58 92.18,58.46 92.18,58.33 92.3,58.2 92.43,58.2 92.56,58.33 92.56,58.46 92.68,58.58 92.87,58.58 93,58.46 93,58.33 93.13,58.2 93.45,58.2 93.57,58.33 93.57,58.91 93.45,59.04 v1(93.16,59.04)
  BOTTOM w0.121: v1(80.37,70.6) 80.1,70.6 79.23,71.46 78.32,71.46 77.91,71.06 77.35,71.06 R31.2 ; 77.91,58.78 81.57,58.78 81.7,58.65 81.7,58.33 81.83,58.2 82.02,58.2 82.14,58.33 82.14,58.65 82.27,58.78 82.46,58.78 82.59,58.65 82.59,58.33 82.71,58.2 83.4,58.2 83.6,58.39 v1(84.05,58.39) 85.32,58.39 85.44,58.27 85.82,58.27 85.87,58.22 86.62,58.22 87.23,57.61 87.65,57.61 87.78,57.48 87.78,55.03 87.91,54.9 88.49,54.9 88.62,55.03 88.62,56.88 88.75,57 89.24,57
DDR_A3: length 65.5
  TOP w0.076: U8.J2 v1(70.14,62.24) ; U31.J2 v1(92.36,63.04)
  TOP w0.121: v1(73.09,70.65) 74.47,69.27 77.26,69.27 77.89,68.65 77.89,67.28 79.79,65.38 v1(79.79,64.81)
  BOTTOM w0.076: 92.87,64.72 92.87,63.59 92.75,63.47 92.21,63.47 91.99,63.24 91.99,61.82 91.67,61.51 90.26,61.51 89.69,62.08 89.69,62.66 89.24,63.11 ; 67.16,65.16 67.16,62.78 67.28,62.65 68.93,62.65 69.32,62.27 70.1,62.27 v1(70.14,62.24) ; 94.01,64.54 93.89,64.43 93.38,64.43 93.26,64.3 93.26,63.35 92.85,62.94 92.85,62.78 92.72,62.65 92.49,62.65 92.36,62.78 v1(92.36,63.04) ; 70.04,65.16 70.2,65 70.65,65 70.81,65.16
  BOTTOM w0.121: 70.04,65.16 70.01,65.19 70.01,65.28 69.95,65.34 69.95,65.76 69.83,65.89 68.62,65.89 68.49,66.01 68.49,66.66 68.11,67.04 68.11,67.22 67.99,67.35 67.28,67.35 67.16,67.22 67.16,65.16 ; R33.2 72.81,78.08 72.81,74.11 72.32,73.62 72.32,71.26 72.93,70.65 v1(73.09,70.65) ; 89.24,63.11 88.14,64.21 87.8,64.21 87.79,64.22 86.92,64.22 86.73,64.41 85.68,64.41 85.49,64.22 80.44,64.22 80.36,64.3 80.08,64.3 79.79,64.59 v1(79.79,64.81) 78.92,65.68 71.03,65.68 70.9,65.56 70.9,65.25 70.81,65.16 ; 94.01,64.54 94.01,64.82 93.89,64.93 93.09,64.93 92.87,64.72
DDR_A4: length 60.8
  TOP w0.076: v1(70.14,57.44) U8.J8 ; v1(92.36,57.44) U31.J8
  TOP w0.121: R34.2 75.48,70.75 75.96,70.26 77.26,70.26 77.69,70.26 79.91,68.05 80.04,67.91 80.39,67.91 81.17,67.14 81.17,66.85 82.44,65.58 82.44,64.78 81.94,64.29 81.94,56.04 81.82,55.92 81.32,55.92 81.19,55.79 81.19,54.96 81.32,54.84 82.46,54.84 82.59,54.96 v1(82.59,55.66)
  BOTTOM w0.076: 91.1,56.69 91.41,57 91.93,57 v1(92.36,57.44) ; 76.3,56.36 76.3,56.74 74.84,58.2 70.32,58.2 70.14,58.02 v1(70.14,57.44)
  BOTTOM w0.121: 76.3,56.36 76.3,55.79 76.17,55.66 75.6,55.66 75.48,55.54 75.48,55.16 75.6,55.03 80.56,55.03 80.68,55.16 80.68,55.85 80.81,55.98 82.46,55.98 82.59,55.85 v1(82.59,55.66) 85.38,55.66 85.84,55.21 86.44,55.21 86.71,54.93 86.71,53.76 86.84,53.63 92.62,53.63 92.75,53.76 92.75,55.09 92.62,55.22 91.22,55.22 91.1,55.35 91.1,56.69
DDR_A5: length 69.5
  TOP w0.076: U31.J3 93.06,61.53 93.06,60.87 93.19,60.74 93.45,60.74 93.57,60.62 93.57,60.08 93.7,59.96 96.63,59.96 96.75,59.84 96.75,59.68 96.63,59.56 93.45,59.56 93.32,59.69 93.32,60.43 93.19,60.55 92.94,60.55 92.81,60.68 92.81,61.31 92.68,61.44 92.49,61.44 92.36,61.57 v1(92.36,62.24) ; v1(70.14,61.44) U8.J3
  TOP w0.121: R35.2 72.3,73.06 72.3,71.34 72.55,71.09 73.36,71.09 74.93,69.52 77.37,69.52 78.14,68.74 78.14,67.65 80.19,65.61 80.19,65.18 80.19,65.18 80.19,65.12 80.23,65.07 80.23,64.62 80.17,64.56 v1(80.17,63.86)
  BOTTOM w0.076: v1(92.36,62.24) 92.36,61.91 91.77,61.31 90.34,61.31 ; 71.19,64.96 71.03,64.81 70.22,64.81 70.09,64.68 70.09,64.49 69.82,64.22 69.38,64.22 69.25,64.1 69.25,63.34 69.13,63.21 68.29,63.21 68.16,63.34 68.16,65.15 68.17,65.16 ; 67.54,65.16 67.54,63.22 67.79,62.97 70.4,62.97 70.52,62.84 70.52,61.56 70.4,61.44 70.14,61.44 v1(70.14,61.44)
  BOTTOM w0.121: 68.17,65.16 68.17,66.52 68.04,66.65 67.66,66.65 67.54,66.52 67.54,65.16 ; 90.34,61.31 90.21,61.31 89.52,62 89.52,62.48 88.04,63.96 88.01,63.96 87.69,63.96 87.68,63.97 86.82,63.97 86.63,64.16 85.79,64.16 85.58,63.95 82.64,63.95 82.55,63.86 v1(80.17,63.86) 79.93,64.11 79.73,64.11 78.4,65.44 71.31,65.44 71.19,65.31 71.19,64.96
DDR_A6: length 52.5
  TOP w0.076: U31.J7 v1(92.36,59.04) 92.36,58.33 92.23,58.2 90.59,58.2 ; 90.46,56.36 90.46,58.08 ; v1(70.14,59.04) U8.J7
  TOP w0.121: v1(87.41,58.05) 87.41,55.28 87.54,55.16 90.33,55.16 90.46,55.28 90.46,56.36 ; 90.46,58.08 90.59,58.2 ; v1(83.29,58.79) 83.29,60.24 83.73,60.68 83.73,61.39 83.36,61.76 83.36,62.99 83.62,63.24 83.62,65.91 82.16,67.36 82.16,67.55 80.81,68.91 80.6,68.91 80.45,69.05 79.48,70.03 79.48,70.57 79.27,70.78 v1(78.61,70.78)
  BOTTOM w0.076: 77.91,59.03 77.76,59.03 77.44,59.35 74.71,59.35 74.46,59.6 74.46,60.16 73.81,60.81
  BOTTOM w0.121: v1(70.14,59.04) 70.14,60.68 70.26,60.81 73.81,60.81 ; 77.91,59.03 82.59,59.03 82.82,58.79 v1(83.29,58.79) 83.82,58.79 83.86,58.83 84.41,58.83 84.48,58.9 85.25,58.9 85.38,58.77 85.39,58.77 85.57,58.59 85.85,58.59 85.98,58.46 87.03,58.46 87.41,58.08 v1(87.41,58.05) ; v1(78.61,70.78) 78.61,70.78 78.4,70.56 75.94,70.56 R36.2
DDR_A7: length 77
  TOP w0.076: 90.28,65.16 90.27,65.15 90.27,64.36 90.4,64.24 91.38,64.24 91.51,64.11 91.51,63.09 v1(91.56,63.04) ; 90.72,64.93 90.72,64.62 90.84,64.49 91.83,64.49 91.96,64.36 U31.K2 ; 69.61,63.09 69.74,62.97 U8.K2
  TOP w0.121: 69.61,63.09 68.49,63.09 68.36,62.97 68.36,62.71 68.24,62.58 64.81,62.58 64.68,62.71 64.68,63.11 64.81,63.24 65.45,63.24 65.57,63.36 65.57,63.6 65.45,63.72 64.81,63.72 64.68,63.85 64.68,64.08 64.81,64.21 65.45,64.21 65.57,64.33 65.57,64.57 65.45,64.69 64.79,64.69 64.66,64.82 64.66,66.85 65.17,67.35 67.92,67.35 68.05,67.22 68.05,66.56 68.17,66.44 v1(69.02,66.44) ; v1(84.56,65.89) 84.56,67.15 80.67,71.04 79.85,71.04 79.29,71.6 R37.2 ; 90.28,65.16 91.2,66.08 92.56,66.08 92.68,66.21 92.68,66.59 92.81,66.71 93.06,66.71 93.19,66.59 93.19,66.21 93.32,66.08 93.51,66.08 93.64,66.21 93.64,66.57 93.76,66.69 93.95,66.69 94.08,66.57 94.08,66.21 94.21,66.08 94.72,66.08 94.84,65.96 94.84,65.57 94.72,65.44 93.38,65.44 93.26,65.32 93.26,63.92 93.13,63.79 92.94,63.79 92.81,63.92 92.81,65.32 92.68,65.44 92.24,65.44 92.12,65.32 92.12,64.86 92,64.74 91.76,64.74 91.64,64.86 91.64,65.32 91.52,65.44 91.1,65.44 90.72,65.06 90.72,64.93
  BOTTOM w0.076: 90,64.86 90,64.23 90.01,64.23 90.01,62.19 90.33,61.87 90.91,61.87 91.16,62.11 91.16,62.63 v1(91.56,63.04)
  BOTTOM w0.121: v1(69.02,66.44) 69.02,66.32 69.14,66.19 69.83,66.19 69.83,66.18 70.2,66.18 70.2,66.19 72.75,66.19 72.76,66.18 79.12,66.18 79.81,65.5 80.34,65.5 80.79,65.95 83.73,65.95 83.79,65.89 v1(84.56,65.89) 85.7,65.89 86.39,65.19 87,65.19 87.23,64.96 88.09,64.96 88.1,64.95 88.88,64.95 88.94,65.01 89.85,65.01 90,64.86
DDR_A8: length 60
  TOP w0.076: U31.K8 v1(91.56,57.44) ; U8.K8 v1(69.34,57.44)
  TOP w0.121: v1(79.03,70.26) 79.17,70.26 79.23,70.2 79.23,69.93 80.21,68.95 80.5,68.66 80.71,68.66 81.92,67.45 81.92,67.26 83.37,65.81 83.37,63.35 83.12,63.09 83.12,60.51 82.84,60.24 82.84,60.13 82.84,58.61 83.22,58.23 83.22,56.93 v1(83.86,56.3)
  BOTTOM w0.076: 77.91,56.72 77.57,57.06 76.3,57.06 74.97,58.39 70.29,58.39 v1(69.34,57.44) ; v1(91.56,57.44) 91.28,57.44 91.15,57.31 91.15,57.31 90.91,57.06
  BOTTOM w0.121: 77.91,56.72 78.33,56.3 v1(83.86,56.3) 84.24,55.92 85.35,55.92 85.36,55.91 85.48,55.91 85.94,55.45 86.54,55.45 86.96,55.04 86.96,54.01 87.08,53.89 92.37,53.89 92.49,54.01 92.49,54.84 92.37,54.96 90.97,54.96 90.84,55.09 90.84,57 90.91,57.06 ; v1(79.03,70.26) 78.98,70.31 75.18,70.31 74.21,71.28 74.21,73.7 74.08,73.82 74.08,75.67 R38.2
DDR_A9: length 67
  TOP w0.076: U31.K3 91.96,61.42 92.09,61.29 92.52,61.29 92.62,61.19 92.62,60.68 92.49,60.55 91.95,60.55 91.88,60.63 91.88,61.11 91.8,61.19 91.65,61.19 91.57,61.11 91.57,60.63 91.5,60.55 91.34,60.55 91.27,60.63 91.27,61.11 91.19,61.19 91.04,61.19 90.96,61.11 90.96,60.63 90.89,60.55 90.74,60.55 90.66,60.63 90.66,61.11 90.58,61.19 90.43,61.19 90.35,61.11 90.35,60.63 90.28,60.55 90.02,60.55 89.89,60.68 89.89,61.38 90.02,61.51 91.41,61.51 91.54,61.63 91.54,62.22 v1(91.56,62.24) ; v1(69.34,61.44) U8.K3
  TOP w0.121: R39.2 74.52,70.96 75.47,70.01 77.37,70.01 77.57,70.01 79.92,67.66 80.29,67.66 80.92,67.04 80.92,66.75 81.99,65.68 v1(81.99,65.15) ; v1(66.27,63.09) 66.01,63.09 65.89,63.22 65.89,64.87 65.76,65 65.06,65 64.93,65.12 64.93,66.65 65.32,67.03 67.54,67.03 67.66,66.9 67.66,66.08 67.79,65.95 69.95,65.95 v1(70.4,65.51)
  BOTTOM w0.076: v1(91.56,62.24) 91.67,62.13 91.67,61.78 91.54,61.66 90.33,61.66 89.85,62.14 89.85,62.72 89.45,63.12 89.45,63.32 89.57,63.44 89.73,63.44 89.85,63.57 89.85,63.85 89.74,63.97 89.33,63.97 ; 67.01,62.35 67.54,61.82 68.93,61.82 69.32,61.44 v1(69.34,61.44)
  BOTTOM w0.121: v1(70.4,65.51) 70.82,65.93 72.07,65.93 72.08,65.94 72.65,65.94 72.66,65.93 79.02,65.93 79.7,65.25 80.2,65.25 80.45,65 81.85,65 v1(81.99,65.15) 82.04,65.19 82.47,65.19 82.59,65.07 82.59,64.58 82.71,64.46 82.95,64.46 83.07,64.58 83.07,65.07 83.19,65.19 83.43,65.19 83.55,65.07 83.55,64.58 83.67,64.46 83.91,64.46 84.03,64.58 84.03,65.07 84.15,65.19 84.4,65.19 84.52,65.07 84.52,64.58 84.64,64.46 84.88,64.46 85,64.58 85,65.06 85.13,65.19 85.64,65.19 85.76,65.06 85.76,64.87 85.95,64.68 86.81,64.68 87.03,64.46 87.89,64.46 87.9,64.45 88.21,64.45 89.13,64.45 89.24,64.34 89.24,64.2 89.25,64.19 89.25,64.05 89.33,63.97 ; v1(66.27,63.09) 67.01,62.35

# Allegro board am335x_gpevm_15x15baseboard_3h0002_layout_rev1_1a.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_ETH: length 22.4
  TOP w0.508: C272.2 J15.SHLD1 J15.SHLD2 C271.2
GND_OSC0: length 14.5
  TOP w0.254: C5.2 101.64,82.08 v1(101.64,81.83) 101.64,81.57 102.02,81.19 C4.2 ; v1(100.29,83.02) 100.29,84.19 98.58,85.89 95.19,85.89 94.23,86.85 93.53,86.85 93.12,86.44 92.31,86.44 92.07,86.2 U2.V11
  BOTTOM w0.254: v1(100.29,83.02) 100.6,82.71 100.62,82.71 C67.2 101,82.33 101.13,82.33 v1(101.64,81.83)
GND_OSC1: length 13.8
  TOP w0.102: 77.1,81.14 77.94,81.14 U2.A5
  TOP w0.121: 77.1,81.14 76.22,81.14 75.24,80.16 71.56,80.16 71.31,79.92 67.56,79.92 C2.1 C3.1
GNDA_ADC: length 44.3
  TOP w0.305: v2(81,83.4) U2.E8
  TOP w0.508: v1(58.9,84.75) 59.66,84.75 59.92,84.49 64.16,84.49 v1(64.17,84.5) 64.41,84.75 R45.1 ; v1(49.44,75.73) v1(57.19,75.73)
  BOTTOM w0.127: 79.56,82.99 79.79,83.22 79.79,83.6 80.05,83.86 80.54,83.86 v2(81,83.4)
  BOTTOM w0.152: 77.15,83.1 79.03,83.1 79.13,82.99 79.56,82.99
  BOTTOM w0.508: C63.2 v1(49.44,75.73) ; v1(58.9,84.75) 58.89,84.73 58.89,81.93 58.88,81.93 58.88,80.73 57.19,79.03 v1(57.19,75.73) ; 77.15,83.1 76.04,83.1 FB10.1 74.46,82.77 74.46,82.97 74.08,83.35 73.06,83.35 72.16,84.25 71.27,84.25 71.03,84.49 R461.1 64.19,84.49 v1(64.17,84.5)
GNDA_TSC: length 61.2
  TOP w0.121: 49.82,57.31 J9.11 ; R45.2 57.12,83.73 53.95,80.56 47.98,80.56 46.69,79.27 44.4,79.27 43.61,80.07 43.61,80.09 v1(43.29,80.4)
  TOP w0.508: C12.2 C11.2 C14.2 C13.2 R51.2 65.19,83.48 R45.2
  BOTTOM w0.121: 49.82,57.31 50.96,57.31 51.22,57.57 51.22,64.68 50.07,65.83 47.73,65.83 42.18,71.38 42.18,79.29 v1(43.29,80.4)
GNDUSB0: length 26
  TOP w0.635: J14.S2 126.87,166 126.87,166.57 126.62,166.82 J14.S4 124.91,168.55 v1(124.62,168.26) ; FB14.2 v1(136.94,168.26) 136.66,168.55 J14.S3 134.82,166.74 134.08,166 J14.S1
  BOTTOM w0.635: v1(124.62,168.26) v1(136.94,168.26)
GNDUSB1: length 16.7
  TOP w0.635: FB19.2 154.6,165.66 J18.S1
  BOTTOM w0.635: J18.S1 151.94,168.31 139.98,168.31 J18.S2
V1_2D: length 3.7
  TOP w0.121: 149.26,16.8 149.28,16.82
  TOP w0.381: C159.1 150.47,17.88 U12.5 149.28,16.82
  BOTTOM w0.762: C242.1 152.8,17.58 v1(152.95,17.31)
  vias: v1(149.58,16.36) v1(155.23,17.31)
V1_2D_EN: length 2.8
  TOP w0.381: v1(147.61,20.74) 147.98,20.37 U12.3
  BOTTOM w0.121: v1(147.61,20.74) 147.36,20.48 147.36,19.98 147.1,19.72 R478.1
V1_8D: length 274
  TOP w0.279: v1(23.84,105.57) 23.77,105.64 U28.17
  TOP w0.305: U16.16 v1(21.87,128.83) ; v1(4.36,111.42) 4.61,111.67 J11.8 ; v1(21.86,116.24) 21.74,116.13 U13.16 ; v1(4.36,129.2) 4.74,128.82 J11.62 ; U15.16 v1(21.87,135.18) ; U14.16 v1(21.87,122.48)
  TOP w0.508: v1(21.87,128.83) 21.87,128.43 21.62,128.18 19.47,128.18 16.65,131 5.52,131 4.36,129.83 v1(4.36,129.2) ; v1(21.87,135.18) 22.53,135.18 23.28,135.93 23.28,140.12 23.91,140.75 26.96,140.75 27.98,139.74 30.77,139.74 34.96,135.55 41.44,135.55 42.58,134.41 50.94,134.41 51.65,135.11 54.23,135.11 57.23,132.12 61.38,132.12 62.52,130.97 66.21,130.97 66.59,130.59 80.67,130.59 84.67,134.6 86.85,134.6 87.44,134.01 97.3,134.01 97.44,134.15 97.94,134.15 98.05,134.26 104.2,134.26 104.87,133.59 118.19,133.59 119.72,132.05 v1(120.18,132.05) 129.37,132.05 131.49,129.93 134.33,129.93 v1(135.8,128.46) C133.1 ; v1(133.01,50.52) 130.53,50.52 128.37,48.36 116.31,48.36 114.96,47.02 v1(113.56,47.02)
  LY3 w0.508: v1(23.84,105.57) 23.13,104.86 18.27,104.86 17.99,105.14 v1(17.39,105.14)
  LY4 w0.483: 132.75,87.13 J8.2 133.56,86.52
  LY4 w0.514: 135.8,123.46 J3.1 ; J3.1 136.71,124.37 ; J3.1 135.8,125.28 ; J3.1 134.89,124.37
  BOTTOM w0.305: R332.2 R331.2 v1(4.61,118.02) ; R329.2 v1(4.48,123.74) ; R334.2 v1(4.61,112.31) ; R330.2 v1(4.48,121.45)
  BOTTOM w0.381: R333.2 3.59,114.59
  BOTTOM w0.508: 20.35,122.72 20.35,120.93 19.72,120.31 19.72,117.51 ; 20.35,122.72 21.63,122.72 v1(21.87,122.48) ; 20.35,122.72 19.98,123.09 19.98,128.31 20.23,128.56 20.23,129.07 ; v1(17.39,105.14) 17.33,105.14 16.87,105.6 16.87,109.28 17.23,109.64 17.23,109.8 17.6,110.17 17.77,110.17 17.82,110.22 17.82,114.74 18.3,115.23 19.52,115.23 19.97,115.68 19.97,116.37 ; 20.23,129.07 19.98,129.32 19.98,134.91 20.48,135.42 C168.1 21.63,135.42 v1(21.87,135.18) ; 20.23,129.07 C170.1 21.63,129.07 v1(21.87,128.83) ; J3.1 v1(135.8,128.46) ; 19.97,116.37 19.72,116.62 19.72,117.51 ; 19.97,116.37 C164.1 21.63,116.37 21.75,116.24 v1(21.86,116.24) ; 3.59,118.02 3.59,112.31 4.23,112.31 ; 3.59,118.02 v1(4.61,118.02) ; 3.59,118.02 3.59,121.45 ; J8.2 132.63,86.65 C138.1 ; 19.72,117.51 R519.2 ; v1(4.36,129.2) 3.59,128.43 3.59,123.74 ; C162.1 3.21,111.42 v1(4.36,111.42) 4.23,111.54 4.23,112.31 ; v1(4.48,121.45) 3.59,121.45 ; 3.59,121.45 3.59,123.74 ; C261.1 113.57,47.01 v1(113.56,47.02) R472.1 ; v1(4.48,123.74) 3.59,123.74 ; 4.23,112.31 v1(4.61,112.31) ; C87.1 23.66,105.75 v1(23.84,105.57)
V3_3D: length 216.4
  TOP w0.203: C191.1 27.49,56.16 v1(28.15,56.16) 28.34,56.34 28.62,56.34 28.65,56.37 28.65,56.37 29.05,56.37 29.27,56.16 U25.4
  TOP w0.254: U32.6 v1(66.86,33.53)
  TOP w0.381: C140.1 50.08,65.7 49.82,65.44 49.82,63.66 ; FB15.1 v1(23.91,47.79)
  TOP w0.508: R386.2 156.88,141.77 155.99,140.88 137.22,140.88 135.95,142.15 129.96,142.15 128.71,143.39 123.19,143.39 116.05,150.53 114.74,150.53 113.98,149.77 112.43,149.77 111.8,149.14 94.91,149.14 92.11,146.34 v1(75.09,146.34) ; v1(66.86,33.53) 66.86,32.84 67.09,32.61 C222.1
  TOP w0.635: 66.86,32.84 59.62,32.84 58.77,33.69 R544.2 58.52,35.73 58.52,38.7 ; 58.52,38.7 58.97,39.15 v1(65.95,39.15) v1(71.03,39.15) v1(73.57,39.15) ; 58.52,38.7 v1(46.97,38.7) ; v1(64.3,45.88) 63.09,44.68 59.03,44.68 57.82,45.88 50.33,45.88 v1(48.3,47.92)
  TOP w0.762: FB17.1 v1(17.56,13.25)
  LY4 w0.514: 69.76,124.73 J6.15 ; J6.15 68.85,125.64 ; J6.15 70.67,125.64 ; J6.15 69.76,126.55 ; J5.39 48.17,137.98 ; J5.39 48.17,136.16 ; J5.39 47.26,137.07 ; J5.39 49.08,137.07 ; 49.82,64.27 49.82,63.66 50.63,63.66
  BOTTOM w0.254: C215.1 65.59,46.03 U27.6
  BOTTOM w0.381: v1(28.15,56.16) 28.14,56.17 C191.1
  BOTTOM w0.508: C134.1 69.76,124.24 J6.15 ; C135.1 v1(48.93,135.29)
  BOTTOM w0.635: R454.2 v1(71.03,39.15) ; v1(46.97,38.7) v1(46.97,47.86) ; C215.1 v1(64.3,45.88) ; 73.57,40.42 v1(73.57,39.15) ; R455.2 v1(65.95,39.15)
  BOTTOM w0.762: v1(102.91,22.26) 102.91,25.56 105.75,28.41 105.75,41.64 R68.1
  vias: v1(113.45,24.55) v1(113.45,23.66) v1(113.45,22.77)
V3_3ETHJCK: length 8.3
  TOP w0.508: J15.2 23.79,12.61 23.15,13.25 FB17.2
V5_0D: length 79.5
  TOP w0.121: U24.E2 U24.E1
  TOP w0.381: J7.2 J7.1 ; U11.11 v1(136.19,12.1)
  TOP w0.508: v1(132.63,126.78) C132.1
  TOP w0.635: 136.05,146.79 134.78,146.79 U22.2 ; 136.05,146.79 U22.3 ; 136.05,146.79 143.1,146.79 ; 144.37,146.79 143.1,146.79 ; 144.37,146.79 148.64,146.79 C270.1 ; 144.37,146.79 U29.3 ; 143.1,146.79 U29.2
  TOP w0.762: C137.1 139.23,88.05 137.71,86.52 J7.2
  TOP w1.27: v1(142.96,4.48) 142.18,5.27 133.62,5.27 133.01,5.88 v1(133.01,10.32)
  LY4 w0.483: 138.01,86.52 J7.2 137.2,87.13 ; 135.11,86.52 J7.1 135.93,87.13
  LY4 w0.514: 132.35,124.37 J3.2 ; J3.2 133.26,125.28 ; J3.2 133.26,123.46
  BOTTOM w0.381: 148.12,147.1 148.37,147.1
  BOTTOM w0.508: v1(132.63,126.78) 133.26,126.15 J3.2 ; 148.37,147.1 v1(149.52,148.25)
  BOTTOM w0.635: C157.1 136.19,13.11 v1(136.19,12.1) 133.01,12.1 133.01,12.1
  BOTTOM w0.762: C136.1 134.66,86.52 J7.1 ; R276.2 R275.2 v1(142.96,4.48)
  BOTTOM w1.27: v1(133.01,10.32) 133.01,16.17 v1(132.24,16.93) 132.24,18.2 128.43,22.01 v1(128.43,26.2)
V5_0D_EN: length 1.6
  TOP w0.121: R386.1 156.79,144.78 U24.A4
V5_0HDMICONN: length 5.8
  TOP w0.305: v1(143.66,9.77) J10.18
  TOP w0.381: v1(144.82,11.09) 144.41,11.49 143.5,11.49 U11.13
  BOTTOM w0.635: 144.9,11.01 v1(144.82,11.09) C158.1
  BOTTOM w0.762: 144.9,11.01 v1(143.66,9.77)
VBAT: length 167.1
  TOP w0.121: U24.A1 U24.A2
  TOP w0.203: U4.36 87.25,37.01 87.11,37.15 ; v1(89.16,29.4) 89.16,29.6 89.25,29.68 U4.6 ; U4.47 85.87,31.89 85.67,31.7 85.67,31.44 ; U4.23 92.87,35.49 93.07,35.7 93.07,35.75 v1(93.33,36) ; v1(87.67,29.48) 87.67,29.5 88.02,29.85 88.02,30.15 88.05,30.18 U4.3 ; v1(90.53,37.63) 90.45,37.55 U4.28 ; 93,31.49 U4.13 ; 85.51,34.29 U4.41
  TOP w0.381: v1(149.39,20.74) 149.28,20.63 U12.1 ; v1(86.91,37.63) 86.97,37.57 86.97,37.29 87.11,37.15 ; R239.2 v1(126.91,79.79) ; 85.67,31.44 85.25,31.03 85.25,30.02 v1(85.25,30.01) ; v1(85.29,34.29) 85.51,34.29 ; v1(93.61,31.15) 93.34,31.15 93,31.49
  TOP w0.502: 87.77,20.36 TP25.1 ; TP25.1 88.81,19.32 ; TP25.1 89.85,20.36 ; TP25.1 88.81,21.4 ; 77.23,10.2 SW1.2 ; SW1.2 79.06,10.2 ; SW1.2 78.14,9.28 ; SW1.2 78.14,11.11
  TOP w0.635: U17.2 11.82,100.49 C173.1 v1(14.52,100.49)
  TOP w0.762: C139.1 129.61,85.76 129.96,86.11 129.96,86.14 130.34,86.52 J8.1 ; C214.1 v1(107.86,158.28)
  TOP w1.016: v1(149.39,20.74) 149.39,21.5 148.88,22.01 144.56,22.01 143.04,20.48 142.15,20.48 v1(142.02,20.61)
  LY3 w1.016: v1(31.91,122.72) 33.95,122.72 34.56,123.33 39.13,123.33 40.04,124.24 48.4,124.24 49.31,123.33 59.71,123.33 59.82,123.23 v1(63.54,123.23)
  LY4 w0.483: 130.67,86.52 J8.1 131.48,87.13
  LY4 w0.514: 106.95,159.93 J16.5 ; J16.5 107.86,159.02 ; J16.5 108.77,159.93 ; J16.5 107.86,160.84 ; SW1.2 79.06,10.2 ; SW1.2 78.14,11.11 ; SW1.2 77.23,10.2 ; SW1.2 78.14,9.28 ; 123.74,59 J19.2 ; J19.2 124.65,59.92 ; J19.2 122.82,59.92 ; J19.2 123.74,60.83 ; TP25.1 88.81,21.4 ; TP25.1 89.85,20.36 ; TP25.1 87.77,20.36 ; TP25.1 88.81,19.32 ; J19.1 123.74,63.37 ; J19.1 124.65,62.46 ; J19.1 122.82,62.46 ; J19.1 123.74,61.54
  BOTTOM w0.381: C141.1 64.14,124.15 64.14,124.68
  BOTTOM w0.508: C160.1 v1(149.39,20.74)
  BOTTOM w0.762: R81.2 6.77,83.1 ; R83.2 6.45,74.33 ; R80.2 6.26,87.41 6.39,87.29 ; R82.2 6.77,78.65
  BOTTOM w1.016: v1(93.61,31.15) 92.38,31.15 C240.1 ; v1(87.67,29.48) 87.54,29.6 87.54,30.43 C254.1 ; J6.19 64.14,125.1 64.14,124.68 63.54,124.08 v1(63.54,123.23) ; C251.1 94.77,36 v1(93.33,36) ; v1(85.25,30.01) 85.25,30.01 85.26,30.01 85.64,29.63 85.64,28.64 84.72,27.72 C236.1 ; 6.45,74.33 6.77,74.65 6.77,86.91 6.39,87.29 6.39,95.03 11.85,100.49 v1(14.52,100.49) ; C252.1 88.72,30.32 89.16,29.88 v1(89.16,29.4) ; C238.1 86.38,38.28 86.91,37.76 v1(86.91,37.63) C253.1 ; C250.1 90.53,36.63 v1(90.53,37.63) ; v1(31.91,101.51) v1(31.91,122.72)
  vias: v1(83.48,20.36) v1(84.75,20.36) v1(85.76,20.36) v1(157.77,148.5) v1(158.53,148.5)
VBUS0_OTG_CAP: length 3.7
  TOP w0.635: J36.2 131.99,153.9 C182.1
VBUS1_OTG_CAP: length 6.6
  TOP w0.502: 153.49,157.71 J37.2 ; J37.2 154.53,156.67 ; J37.2 154.53,158.75
  TOP w0.635: C185.1 J37.2
VDD1_SMPS: length 25.5
  TOP w0.254: U32.8 v1(67.79,35.15)
  TOP w0.635: v1(71.79,45.38) v1(71.79,44.74) 73.1,44.74 73.36,45 v1(75.54,45) 80.68,45 ; v1(74.91,36.4) 74.12,36.4 73.68,36.85 R46.1
  LY3 w0.514: J19.6 124.65,49.76 ; J19.6 122.82,49.76 ; J19.6 123.74,48.84 ; J19.6 123.74,50.67
  BOTTOM w0.635: v1(74.91,36.4) 74.91,44.36 v1(75.54,45)
  vias: v1(81.06,45.38) v1(81.44,46.01) v1(81.83,45.38)
VDD2_SMPS: length 94.3
  BOTTOM w0.254: U27.8 69.4,47.03 69.51,46.93 v1(70.01,46.93)
  BOTTOM w1.016: v1(77.76,38.26) 77.76,36.3 75.54,34.07 75.54,24.04 81.42,18.16 86.99,18.16 87.46,17.69 93.31,17.69 93.57,17.69 94.59,18.71 107.48,18.71 107.99,19.21 117.39,19.21 118.66,20.48 118.66,32.55 119.04,32.93 119.04,37.69 121.45,40.11 121.45,44.85 122.85,46.25 122.85,46.33 J19.7
  vias: v1(70.52,48.42) v1(70.52,47.66) v1(76.62,38.26)
VDD3_SMPS: length 35.1
  TOP w0.508: v1(91.35,45.88) 92,45.88 R470.1 92.23,45.12 v1(91.35,45.12)
  TOP w0.635: R470.1 92.5,45.38 97.13,45.38 97.32,45.57 108.11,45.57 109.99,43.69 122.75,43.69 J19.8
VDD_CORE: length 62.6
  TOP w0.305: U2.J12 v2(84.2,87.4)
  TOP w0.381: v2(88.2,87.4) U2.N12 ; U2.K8 v2(85.8,83.4) U2.L8 v2(86.6,83.4) ; U2.N8 v2(88.2,84.2) U2.N9 ; U2.M13 v2(87.4,88.2) U2.N13 ; U2.L6 v2(85.8,81.8) U2.K6 ; U2.F7 v2(82.6,82.6) U2.G7 ; v2(85.8,87.4) U2.K12 ; v2(86.6,82.6) U2.L7 ; v2(86.6,84.2) U2.L9 ; v2(87.4,86.6) U2.M11 ; U2.H11 v2(83.4,86.6) ; U2.G6 v2(82.6,81.8) U2.F6 ; v2(82.6,85.8) U2.G10
  TOP w0.635: C17.1 v1(67.35,73.7)
  TOP w1.016: R32.2 70.54,45.78 71.16,46.39 73.32,46.39 ; v1(66.46,56.43) v1(66.46,57.06) v1(65.89,57.63) 65.26,58.26 64.99,58.26 62.01,61.24 62.01,66.69 65.19,69.86 65.19,70.86 65.35,71.03 ; 65.35,71.03 65.35,71.7 v1(66.46,72.81) v1(66.9,73.25) v1(67.35,73.7) ; 65.35,71.03 C232.1
  BOTTOM w0.381: v2(85.8,83.4) 85.65,83.4 85.19,83.86 C24.1 ; C36.1 88.05,84.35 v2(88.2,84.2) ; v2(85.8,87.4) 85.5,87.1 C34.1 ; v2(82.6,85.8) 82.6,85.37 C19.1 ; C35.1 86.14,84.66 v2(86.6,84.2)
  BOTTOM w0.635: 66.2,77 v1(65.06,77) ; C23.1 v1(70.14,72.94)
  BOTTOM w1.016: v1(65.89,57.63) v1(66.46,57.06) v1(66.46,56.43) 67.09,55.8 67.09,52.37 69.95,49.5 71.99,49.5 72.31,49.19 73.7,49.19 74.97,47.92 v1(74.97,46.65)
  vias: v1(73.57,46.65) v1(74.33,46.01)
VDD_MPU: length 77.9
  TOP w0.381: U2.J13 v2(84.2,88.2) U2.H13 83.74,87.8 83.62,87.92 83.18,87.92 83.06,87.8 U2.G13 v2(82.6,88.2) U2.F13 v2(81.8,87.4) U2.F12 U2.F11 v2(81.8,85.8) U2.F10
  TOP w0.635: v1(73.95,34.81) 73.85,34.71 73.19,34.71 72.68,34.2 R46.2
  LY3 w1.016: v1(66.2,65.32) v1(66.2,65.95) v1(66.2,66.59) 66.2,67.73 65.44,68.49 64.86,68.49 63.49,69.86 63.49,77.46 60.92,80.02 60.92,81.09 61.64,81.81 64.92,81.81 64.93,81.83
  LY4 w1.016: v1(73.98,33.26) v1(73.98,34.05) 73.95,34.07 v1(73.95,34.81) 73.95,36.87 75.09,38.01 75.09,42.96 76.43,44.3 76.43,46.71 74.46,48.68 74.46,51.6 72.94,53.12 69.13,53.12 67.7,54.55 67.7,58.49 67.25,58.94 67.25,63.38 66.2,64.43 v1(66.2,65.32) v1(66.2,65.95) v1(66.2,66.59)
  BOTTOM w0.381: C83.1 84.42,87.98 v2(84.2,88.2) ; v2(81.8,85.8) 81.8,85.15 C53.1 ; C41.1 81.8,86.69 v2(81.8,87.4)
  BOTTOM w0.635: v1(71.67,81.83) 71.41,81.57 C56.1 ; v1(65.32,80.81) 65.44,80.94 66.19,80.94 C246.1 ; 69.38,81.7 70.01,82.33 v1(70.52,82.33)
VDD_RTC: length 6
  TOP w0.381: v2(80.2,81.8) U2.D6
  BOTTOM w0.203: 79.03,82.27 79.54,82.27 79.58,82.23 79.58,82.23 79.83,81.98 79.83,81.98 80.01,81.8 v2(80.2,81.8)
  BOTTOM w0.508: C65.1 76.58,80.81 76.89,81.13 76.91,81.13 78.05,82.27 79.03,82.27
VDDA1P8V_USB0: length 82.1
  TOP w0.381: v2(89.8,90.6) U2.R16 ; v2(88.2,90.6) U2.N16
  TOP w0.508: v1(116.62,132.63) 103.21,132.63 102.55,133.29 98.58,133.29 98.58,133.15 98.07,132.63 97.33,132.63 97.14,132.83 95.77,132.83 v1(95.54,132.6) ; R502.2 114.72,141.1 114.72,139.67 115.86,138.53 v1(115.86,136.94) C61.1
  LY4 w0.381: v2(89.8,90.6) 89.24,91.16 88.75,91.16 88.2,90.61 v2(88.2,90.6)
  BOTTOM w0.508: v2(88.2,90.6) 88.49,90.89 88.49,91.03 89.06,91.6 89.06,94.06 89.84,94.84 90.78,94.84 91.41,95.48 91.41,96.26 92.92,97.78 92.92,101.01 95.52,103.6 95.52,105.85 94.78,106.59 94.78,111.16 96.05,112.43 96.05,116.12 95.54,116.62 95.54,127.99 95.92,128.37 95.92,131.1 95.54,131.48 v1(95.54,132.6) ; v1(116.62,132.63) 116.62,136.18 v1(115.86,136.94)
VDDA3P3V_USB0: length 76.1
  TOP w0.381: v2(89.8,89.8) U2.R15 ; v2(88.2,89.8) U2.N15
  TOP w0.508: C62.1 109.58,136.88 109.58,137.82 ; 109.58,137.82 109.58,137.89 107.58,139.89 R504.2 ; 109.58,137.82 v1(109.59,137.81) ; v1(92.87,96.56) 92.87,97.08 94.32,98.52 94.32,102.57 96.4,104.66 v1(108.88,104.66)
  LY3 w0.102: v2(89.8,89.8) 89.79,89.8 ; 91.32,91.35 91.2,91.48
  LY3 w0.127: 90.19,90.19 90.92,90.19 91.05,90.32 91.05,91.2 91.04,91.2 90.32,91.2 90.19,91.07 90.19,90.19 ; 90.19,90.19 90.18,90.18
  LY3 w0.254: 90.18,90.18 v2(89.8,89.8)
  LY3 w0.508: 91.05,91.2 91.2,91.35 91.2,93.48 92.87,95.16 v1(92.87,96.56)
  BOTTOM w0.102: 88.62,89.38 88.2,89.8 v2(88.2,89.8) 88.58,90.18 89.42,90.18 v2(89.8,89.8) 89.58,89.58 89.39,89.58 89.19,89.38 88.62,89.38
  BOTTOM w0.508: v1(109.59,137.81) 108.88,137.1 v1(108.88,104.66)
VDDA_ADC: length 153.9
  TOP w0.121: 124.75,160.57 124.74,160.57 124.62,160.69 124.62,160.69
  TOP w0.508: v1(47.92,78.4) 48.3,78.78 v1(53.76,78.78) ; v1(58.01,86.65) 58.07,86.59 65.32,86.59 v1(65.63,86.91) 65.63,88.34 65.64,88.34 65.64,88.5 R30.1 ; v1(124.37,160.95) 124.75,160.57 R565.2 125.82,160.01 Q5.S
  LY3 w0.508: v1(112.25,108.85) 90.97,108.85 89.78,107.66 82,107.66 80.68,106.34 80.68,104 79.18,102.5 79.18,98.79 76.49,96.1 73.11,96.1 71.11,94.09 71.11,90.38 70.06,89.34 66.74,89.34 65.63,88.24 v1(65.63,86.91)
  BOTTOM w0.381: R462.1 65.25,87.29 v1(65.63,86.91)
  BOTTOM w0.508: v1(112.25,108.85) 112.25,123.91 114.03,125.69 114.03,126.99 115.56,128.51 115.56,130.21 120.79,135.44 120.79,157.36 v1(124.37,160.95) ; v1(47.92,78.4) R501.2 ; FB9.1 53.7,78.72 v1(53.76,78.78) 55.92,78.78 58.25,81.11 58.25,82.19 58.25,82.2 58.25,85.69 58.01,85.93 v1(58.01,86.65)
VDDH_PHY: length 2.8
  TOP w0.762: v1(28.49,53.38) 28.23,53.12 C192.1
  BOTTOM w0.762: v1(26.45,57.95) 26.71,58.2 R391.2 ; R389.1 v1(28.49,53.38)
VDDL_PHY: length 14.7
  TOP w0.203: U25.47 31.38,59.06 v1(31.33,59.12)
  TOP w0.508: FB16.2 27.98,61.8 L7.1 28.51,61.27 C256.1 30.03,61.12 31.28,61.12 C197.1 31.41,60.49 31.28,60.36 31.28,59.17 v1(31.33,59.12) ; R394.1 v1(33.31,62.9)
  BOTTOM w0.508: v1(33.31,62.9) 33.31,61.63 31.33,59.65 v1(31.33,59.12) 31.53,58.91 C196.1
VDDMPU_MON: length 4.8
  TOP w0.381: R561.1 73.82,78.4 76.87,78.4 77.48,79 U2.A2
VDDS_DDR: length 94.4
  TOP w0.305: 95.03,67.22 95.22,67.22 v1(95.8,67.79)
  TOP w0.381: v1(97.96,61.44) U31.C3 ; v1(75.73,58.2) 75.67,58.27 75.67,58.3 U8.C7 ; v1(99.56,63.84) U31.A1 ; v1(68.54,63.84) U8.L1 ; v1(90.76,63.84) U31.L1 ; v1(73.34,63.84) U8.E1 ; v1(95.56,63.84) U31.E1 ; v1(77.33,56.64) U8.A9 ; v1(77.33,63.84) U8.A1 ; v1(99.56,56.64) U31.A9 ; v1(97.96,58.24) U31.C7 ; v1(75.74,61.44) U8.C3 ; v1(73.34,56.64) U8.E9 ; v1(97.96,56.64) U31.C9 ; v1(75.74,56.64) U8.C9 ; v1(70.94,56.64) U8.H9 ; v1(97.96,63.84) U31.C1 ; v1(95.56,56.64) U31.E9 ; v1(93.16,56.64) U31.H9 ; v1(75.74,63.84) U8.C1
  TOP w0.508: v1(67.6,68.62) 67.6,69.51 67.86,69.76 C266.1 68.76,68.7 v1(68.62,68.55)
  TOP w0.635: R467.1 103.8,28.37 v1(103.8,29.37) v1(103.8,30.64) ; R508.1 107.61,69.44 107.35,69.19 v1(105.6,69.19) v1(104.76,69.19) ; J19.9 120.56,38.96 v1(103.8,38.96)
  BOTTOM w0.254: v1(77.33,56.64) 76.87,56.17 C155.1 ; v1(97.96,58.24) 97.83,58.37 C195.1
  BOTTOM w0.305: v1(68.62,68.55) 69,68.17 C125.1
  BOTTOM w0.381: v1(99.56,63.84) 99.48,63.92 C216.1 ; C181.1 99.73,56.46 v1(99.56,56.64) ; C188.1 90.84,63.92 v1(90.76,63.84) ; v1(70.94,56.64) 70.94,55.82 70.9,55.79 ; v1(73.34,56.64) 73.13,56.43 C126.1 ; C202.1 96.3,64.49 95.65,63.84 v1(95.56,63.84) ; v1(93.16,56.64) 93.16,55.82 C174.1 ; v1(77.33,63.84) 77.25,63.92 C217.1 ; v1(97.57,54.8) C189.1 97.95,56.17 97.95,56.63 v1(97.96,56.64) ; C218.1 68.62,63.92 v1(68.54,63.84) ; C266.1 v1(67.6,68.62) ; v1(73.34,63.84) 73.55,63.84 74.08,64.36 C219.1 ; C221.1 75.6,61.3 v1(75.74,61.44) ; v1(97.96,61.44) 97.83,61.3 C156.1
  BOTTOM w0.635: v1(103.8,29.37) v1(103.8,30.64) v1(103.8,38.96) 103.8,41.88 98.4,47.28 98.4,49.57 99.73,50.9 v1(99.73,55.03) v1(99.1,55.03)
VDDS_OSC: length 47.5
  TOP w0.305: U2.R11 v2(89.8,86.6)
  LY4 w0.508: v1(102.97,81.06) 101.38,81.06 101,81.44 101,83.48 100.49,83.98 97.31,83.98 96.17,82.84 94.66,82.84 93.51,84 93.51,85.25 v1(93.79,85.53)
  BOTTOM w0.381: v2(89.8,86.6) 90.87,85.53 v1(93.79,85.53)
  BOTTOM w0.508: R506.1 113.54,65 110.72,65 109.83,65.89 109.83,77.57 106.34,81.06 v1(102.97,81.06) 101.26,81.06 C67.1
VDDS_PLL_CORE_LCD: length 36.1
  TOP w0.102: U2.R10 89.41,85.4
  TOP w0.381: 89.41,85.4 v2(89.8,85.01)
  LY4 w0.508: v2(89.8,85.01) 90.02,85.23 90.02,85.24 90.36,85.58 91.02,85.58 94.4,82.21 97.94,82.21 98.26,81.89 v1(99.35,81.89)
  BOTTOM w0.508: R503.1 107.51,65.67 C64.1 107.48,66.39 107.51,66.42 107.51,78.37 105.45,80.43 100.75,80.43 100.05,81.13 100.05,81.2 99.68,81.57 99.67,81.57 v1(99.35,81.89)
VDDS_PLL_DDR: length 44.2
  TOP w0.381: U2.E7 v2(81,82.6)
  LY3 w0.102: 80.61,82.98 79.93,82.98 79.54,82.59 79.92,82.21 80.62,82.21 81,82.59 v2(81,82.6) 80.99,82.6 80.61,82.98
  LY3 w0.508: 79.54,82.59 78.65,82.59 75.41,79.35 68.81,79.35 v1(68.24,78.78)
  BOTTOM w0.508: v1(68.24,78.78) 68.24,75.08 68.3,75.02 68.3,73.12 65.7,70.52 65.7,69.51 62.9,66.71 C73.1 62.9,59.16 59.95,56.2 R507.2
VDDS_PLL_MPU: length 47.7
  TOP w0.102: U2.H15 v2(83.4,89.8)
  TOP w0.508: v1(94.24,117) 94.24,115.86 R497.2
  LY3 w0.508: v1(84.26,113.52) 84.9,113.52 85.19,113.82 91.21,113.82 92.34,112.69 v1(94.27,112.69)
  LY4 w0.102: 82.18,90.21 82.18,89.6 82.4,89.38 82.97,89.38 83.39,89.8 v2(83.4,89.8) 83.4,89.84 83,90.24 ; 82.18,90.21 82.18,90.72 82.49,91.03 83,91.03 83,90.24 ; 82.18,90.21 82.97,90.21 83,90.24
  LY4 w0.508: 83,91.03 83,92.56 82.46,93.1 82.46,94.33 81.78,95.01 81.78,97.46 81.71,97.53 81.71,98.05 81.78,98.12 81.78,98.16 82.09,98.47 82.6,98.47 83.06,98.93 83.06,100.33 83.86,101.13 v1(84.49,101.13)
  BOTTOM w0.508: v1(84.49,101.13) 84.04,101.58 84.04,106.4 84.26,106.62 v1(84.26,113.52) ; v1(94.27,112.69) C70.1 94.27,114.34 94.24,114.37 v1(94.24,117)
VDDS_RTC: length 37.2
  TOP w0.305: v2(80.2,82.6) U2.D7
  BOTTOM w0.508: v1(70.52,81.5) 70.07,81.05 70.07,80.74 68.94,79.61 68.94,72.62 66.33,70.01 66.33,68.24 65.12,67.03 C66.1 64.43,58.58 64.43,57.06 64.94,56.55 64.94,52.43 64.68,52.17 64.68,50.14 63.85,49.31 R505.1
VDDS_SRAM_CORE_BG: length 50.9
  TOP w0.381: v2(81,84.2) U2.E9
  TOP w0.508: v1(50.2,102.53) 50.91,103.24 51.47,103.24 52.06,102.65 66.84,102.65 66.97,102.78 v1(67.6,102.78)
  BOTTOM w0.102: v2(81,84.2) 80.28,84.2 79.86,84.62 78.84,84.62
  BOTTOM w0.508: R500.2 49.11,102.75 49.97,102.75 v1(50.2,102.53) 50.33,102.4 51.09,102.4 ; 78.84,84.62 78.59,84.37 75.86,84.37 74.53,85.7 73.51,85.7 72.05,87.16 72.05,87.71 71.26,88.5 68.92,88.5 67.44,89.97 67.44,93.35 67.09,93.7 67.09,100.8 67.6,101.31 v1(67.6,102.78)
VDDS_SRAM_MPU_BB: length 60.9
  TOP w0.381: v2(80.2,85.8) U2.D10
  TOP w0.508: v1(67.22,107.4) 66.36,106.54 58.84,106.54 57.97,107.4 v1(51.93,107.4)
  BOTTOM w0.381: 79.59,86.38 79.96,86.02 79.98,86.02 v2(80.2,85.8)
  BOTTOM w0.508: C69.1 51.93,98.92 v1(51.93,107.4) ; 79.59,86.38 77.41,86.38 76.82,86.97 74.56,86.97 74.56,86.97 74.03,86.97 74.03,86.97 73.25,86.97 72.68,87.54 72.68,87.98 71.52,89.14 69.62,89.14 68.08,90.68 68.08,93.67 67.73,94.02 67.73,100.54 68.25,101.06 68.25,104.44 68.25,104.44 68.25,106.37 v1(67.22,107.4)
  BOTTOM w0.635: R499.2 49.28,98.08 v1(50.08,98.08) 50.2,97.95 C69.1
VDDSHV1: length 384.9
  TOP w0.305: v1(147.53,117.66) 147.76,117.44 U9.39 ; U9.37 148.76,117.38 v1(148.5,117.64) ; U9.34 v1(150.26,117.66) ; v1(148.37,98.08) 148.75,97.7 U9.12
  TOP w0.381: U15.3 25.02,136.48 24.7,136.16 v1(24.7,136.05) 24.93,135.83 U15.2 ; v1(24.65,135.01) 24.81,135.18 U15.1
  TOP w0.635: v1(153.45,95.64) 153.45,94.3 152.64,93.48 148.86,93.48 148.5,93.84 C128.1 148.5,95.16 v1(148.37,95.29) ; v1(148.37,98.08) 148.37,98.31 147.76,98.92 145.66,98.92 v1(145.57,98.82) ; v1(147.53,117.66) 147.53,118.45 C131.1 C130.1 150.48,118.45 150.48,117.89 v1(150.26,117.66)
  TOP w0.762: v1(25.12,154.66) 30.45,154.66 31.2,153.91 56.73,153.91 59.37,151.27 62.62,151.27 63.64,150.25 66.15,150.25 69.68,146.72 73.32,146.72 73.95,147.36 90.84,147.36 93.38,149.9 111.34,149.9 112.08,150.63 113.55,150.63 114.31,151.4 117.11,151.4 123.81,144.69 129.03,144.69 130.61,143.12 139.38,143.12 140.54,141.96 v1(145.64,141.96) ; v1(54.65,85.89) 54.09,86.45 v1(47.92,86.45) 45.45,86.45 42.35,83.35 v1(27.22,83.35)
  LY3 w0.635: v1(153.45,95.64) 151.68,93.86 151.68,88.18 150.95,87.45 150.95,73.35 147.29,69.7 122.43,69.7 119.54,72.58 v1(119.51,72.58)
  BOTTOM w0.635: v1(148.37,98.08) 148.5,97.95 C127.1 148.5,95.41 v1(148.37,95.29) ; C129.1 v1(148.5,117.64) ; R130.2 v1(153.45,95.64) ; R493.2 v1(119.51,72.58) ; v1(24.65,135.01) 25.41,135.01 C167.1 25.5,135.42 24.86,136.05 v1(24.7,136.05)
  BOTTOM w0.762: 146.09,96.05 145.58,96.56 R131.2 145.43,97.34 145.43,98.68 v1(145.57,98.82) 145.91,99.17 145.91,99.66 146.52,100.27 146.52,105.19 146.65,105.32 146.65,116.78 v1(147.53,117.66) ; 27.34,137.32 27.34,139.74 25.12,141.96 v1(25.12,154.66) ; 27.34,137.32 27.34,136.18 26.58,135.42 C167.1 25.82,133.62 25.56,133.36 25.56,129.03 ; 27.34,137.32 R518.2 ; v1(147.53,117.66) 147.53,118.99 145.91,120.61 145.91,133.26 146.34,133.69 146.34,137.96 145.64,138.66 v1(145.64,141.96) ; v1(147.53,117.66) 148.47,117.66 v1(148.5,117.64) ; C169.1 25.56,129.03 ; 25.56,129.03 25.56,124.24 25.44,124.12 25.44,119.49 26.96,117.97 26.96,97.83 26.58,97.45 26.58,95.21 26.81,94.98 26.81,88.89 26.58,88.66 26.58,84.06 27.22,83.43 v1(27.22,83.35) ; FB1.1 FB2.1 54.65,84.55 v1(54.65,85.89)
VDDSHV2: length 76.1
  TOP w0.254: C74.1 21.63,111.9 22.27,111.25 U28.5 ; U28.21 26.96,108.37 C15.1
  TOP w0.381: v1(27.85,108.37) C15.1
  TOP w0.508: C74.1 v1(20.87,112.56) ; 27.98,111.67 v1(28.74,111.67)
  TOP w0.635: v1(111.99,100.55) 106.15,100.55 v1(105.75,100.95) ; v1(77.81,119.1) 78,118.91 83.67,118.91 85,120.24 90.78,120.24 91.38,120.84 103.71,120.84 104.05,120.49 104.98,120.49 v1(105.04,120.43)
  BOTTOM w0.635: J6.11 C148.1 75.37,123.86 75.75,123.48 75.75,121.71 77.03,120.43 77.05,120.43 77.63,119.85 77.63,119.82 77.81,119.65 v1(77.81,119.1) ; R545.2 111.64,96.71 FB5.1 v1(111.99,100.55) ; v1(105.75,100.95) 105.66,101.05 105.59,101.05 104.37,102.27 104.37,113.19 105.57,114.4 105.57,119.91 105.06,120.43 v1(105.04,120.43)
VDDSHV3: length 10
  TOP w0.635: FB20.1 FB21.1 127.86,137.51 128.69,136.69 132.27,136.69 R546.2
VDDSHV4: length 55.8
  TOP w0.254: U19.10 v1(56.87,144.06)
  TOP w0.381: U20.10 v1(71.92,148.12)
  TOP w0.508: J13.4 53.87,147.18 54.08,146.98 v1(54.27,146.98) 54.46,146.98 54.73,147.24 J13.19 ; C255.1 v1(54.1,145.03)
  TOP w0.635: v1(128.12,142.28) 128.12,142.28 127.87,142.53 122.97,142.53 115.73,149.77 v1(115.35,149.77)
  BOTTOM w0.635: R369.2 v1(43.09,148.88) ; v1(54.27,146.98) 53.76,147.48 C180.1 ; v1(128.12,142.28) 128.12,137.13 130.4,134.85 FB4.1 130.91,132.5 131.61,132.5 133.13,130.97 134.37,130.97 R494.2 ; R365.2 46.39,149.52 v1(46.01,149.9) ; v1(46.14,164.38) 46.14,165.9 46.52,166.28 R370.2 R371.2 ; v1(55.66,164.38) 55.66,165.39 56.55,166.28 R372.2 R373.2 ; v1(48.17,149.9) 48.55,149.52 R366.2 R368.2 R367.2
VDDSHV5: length 224.9
  LY3 w0.762: v1(114.59,138.09) 111.42,138.09 109.77,139.74 v1(103.06,139.74) ; v1(114.53,58.39) 114.53,56.49 111.54,53.5 102.91,53.5 100.62,51.22 73.19,51.22 71.79,49.82 58.2,49.82 56.81,48.42 51.49,48.42 50.2,49.71 40.15,49.71 39.66,50.2 28.1,50.2 27.72,49.82 25.44,49.82 24.55,50.71 v1(24.55,52.62) ; v1(130.4,128.46) 127.74,128.46 127,129.2 126.37,129.2 126.12,129.45 114.72,129.45 v1(114.59,129.32)
  LY4 w0.762: v1(24.17,59.85) 24.17,59.09 24.55,58.71 v1(24.55,52.62) ; v1(114.59,138.09) v1(114.59,129.32) 114.59,94.14 115.61,93.13 115.61,73.19 117.75,71.04 117.75,64.06 117.89,63.92 117.89,59.6 116.75,58.46 114.59,58.46 v1(114.53,58.39)
  BOTTOM w0.381: R388.2 v1(24.55,52.62)
  BOTTOM w0.508: R409.2 24.55,59.47 v1(24.17,59.85)
  BOTTOM w0.635: FB6.1 v1(114.53,58.39)
  BOTTOM w0.762: R495.2 v1(103.06,139.74) ; FB3.1 v1(130.4,128.46)
VDDSHV6: length 196.8
  TOP w0.381: R568.2 v1(130.87,33.84) ; U14.2 27.06,123.13 v1(27.47,122.72) 27.23,122.48 U14.1 ; U16.2 24.96,129.48 v1(24.68,129.2) 25.05,128.83 U16.1 ; U11.24 144.67,18.6 v1(144.94,18.33) ; U13.3 25.02,117.43 v1(24.8,117.64) ; v1(77.7,102.45) 77.7,100.94 77.89,100.76 77.89,100.23 77.7,100.05 77.7,99.28 v1(77.99,99) ; v1(24.85,115.79) 24.86,115.79 25.19,116.13 U13.1 ; U21.1 63.29,145.06 R378.2 ; R567.2 v1(130.87,32.55) ; R306.2 v1(130.82,31.43) ; FB12.2 165.58,18.33 166.12,18.33 v1(166.14,18.31) ; D8.2 v1(159.68,17.44) ; U7.8 v1(138.4,69) ; R570.2 v1(130.82,30.29)
  TOP w0.635: U26.5 25.05,63.79 C213.1 25.06,64.55 24.68,64.93 v1(21.37,64.93) ; v1(25.18,80.87) 39.92,80.87 40.29,81.25 52.23,81.25 52.23,81.25 v1(52.93,81.25) ; R378.2 v1(63.16,145.96) ; R412.1 146.91,155.36 146.09,156.18 v1(146.09,157.2) ; J2.5 v1(22.01,94.27) ; R382.1 v1(138.98,151.99) 138.95,151.99 138.71,152.24 138.71,154.64 139.42,155.36 144.31,155.36 145.33,156.37 v1(145.33,157.14)
  LY3 w0.381: v1(54.9,98.08) 55.16,97.83 69.63,97.83 v1(70.65,98.84) 71.54,99.73 77.51,99.73 77.99,99.25 v1(77.99,99)
  BOTTOM w0.381: R72.2 v1(139.74,68.87) C116.1 138.59,69 v1(138.4,69) ; R555.2 R554.2 77.76,102.3 77.7,102.35 v1(77.7,102.45) ; R548.2 R547.2 78.52,98.46 v1(77.99,99) ; R559.2 v1(10.83,49.31) ; C149.1 v1(144.94,18.33) ; v1(70.65,98.84) 70.68,98.81 70.68,98.5 71.03,98.15 R553.2 R552.2
  BOTTOM w0.508: v1(165.9,84.11) R107.2 R106.2 ; v1(165.82,61.51) R99.2 R98.2 ; R102.2 R103.2 v1(165.82,51.35) ; v1(166.14,18.31) 164.88,18.31 C243.1 ; R110.2 R111.2 165.77,73.95 v1(165.82,73.9) ; v1(165.82,66.59) R97.2 R96.2 ; R100.2 R101.2 v1(165.82,56.43) ; R104.2 R105.2 v1(165.82,89.19) ; v1(165.82,78.96) 165.76,79.03 R109.2 R108.2
  BOTTOM w0.635: 25.18,89.19 R6.2 v1(25.18,80.87) 25.18,69.38 21.37,65.57 v1(21.37,64.93) ; 25.18,89.19 25.74,89.19 v1(25.87,89.32) ; 25.18,89.19 R71.2 ; C163.1 25.02,117.42 v1(24.8,117.64) ; C165.1 27.3,122.55 v1(27.47,122.72) ; R70.2 29.21,89.02 28.22,89.02 v1(27.49,88.3) ; C115.1 v1(22.01,94.27) ; v1(52.93,81.25) 52.93,86.88 R496.2 53.72,87.67 54.11,87.67 54.58,88.14 54.58,90.65 FB8.1 FB7.1 53.25,94.27 54.43,95.45 54.43,97.61 v1(54.9,98.08)
AM335X_AIN0: length 68.1
  TOP w0.102: 77.1,82.59 78.65,82.59 79,82.24 U2.B6
  TOP w0.121: v1(41.01,77.58) 41.32,77.9 41.39,77.9 41.76,78.27 46.74,78.27 48.21,79.74 54.62,79.74 57.11,82.23 60.25,82.23 60.47,82.01 64.57,82.01 64.67,81.9 65.62,81.9 65.94,82.23 68.64,82.23 v1(68.87,82.46) 69.76,82.46 70.4,83.1 72.62,83.1 73.1,82.62 77.07,82.62 77.1,82.59
  BOTTOM w0.095: 47.79,56.68 49.19,56.68 49.82,56.04
  BOTTOM w0.121: v1(41.01,77.58) 41.01,71.31 47.1,65.21 47.1,57.19 47.61,56.68 47.79,56.68 ; R461.2 v1(68.87,82.46)
AM335X_AIN1: length 77.8
  TOP w0.102: v2(79.4,83.4) U2.C7
  TOP w0.121: v1(43.42,85.53) 43.42,86.55 44.72,87.84 55.36,87.84 57.51,85.69 v1(64.93,85.69)
  BOTTOM w0.095: 49.82,54.77 49.19,55.41 47.79,55.41
  BOTTOM w0.102: 77.1,83.54 77.73,83.54 77.79,83.48 78.84,83.48 78.92,83.4 v2(79.4,83.4)
  BOTTOM w0.121: 47.79,55.41 47.48,55.41 46.19,56.7 46.19,65.16 40.25,71.1 40.25,77.84 40.75,78.34 40.75,80.43 43.11,82.78 43.11,85.22 v1(43.42,85.53) ; R462.2 64.43,86.2 v1(64.93,85.69) 65.31,85.31 65.75,85.31 65.82,85.38 71.16,85.38 71.54,85 74.21,85 75.67,83.54 77.1,83.54
AM335X_AIN2: length 74.8
  TOP w0.102: 77.1,83.41 78.59,83.41 79,83 U2.B7
  TOP w0.121: 77.1,83.41 76.55,83.41 76.08,83.89 75.19,83.89 74.21,84.87 70.52,84.87 70.4,84.75 70.4,84.37 69.95,83.92 69.13,83.92 67.93,82.72 66.14,82.72 65.7,82.72 65.38,82.4 64.88,82.4 64.77,82.51 60.87,82.51 60.65,82.72 56.62,82.72 54.2,80.3 48.07,80.3 46.8,79.02 40.78,79.02 40.19,79.62 v1(39.71,79.62)
  BOTTOM w0.095: 47.91,54.14 49.18,54.14 49.82,53.5
  BOTTOM w0.121: v1(39.71,79.62) 39.71,70.52 45.38,64.86 45.38,55.76 47,54.14 47.91,54.14
AM335X_AIN3: length 73.2
  TOP w0.102: 77.1,83 U2.A7
  TOP w0.121: 77.1,83 76.78,83 76.65,82.87 73.2,82.87 72.72,83.35 71.49,83.35 71.23,83.6 69.16,83.6 68.17,82.62 68.03,82.47 66.04,82.47 66.04,82.48 65.84,82.48 65.51,82.15 64.78,82.15 64.67,82.26 60.74,82.26 60.53,82.47 57.01,82.47 56.87,82.33 54.52,79.98 48.11,79.98 46.8,78.68 v1(39.27,78.68)
  BOTTOM w0.095: 49.82,52.23 49.19,52.87 47.79,52.87
  BOTTOM w0.121: 47.79,52.87 44.79,55.87 44.79,65.01 39.27,70.53 v1(39.27,78.68)
AM335X_AIN4: length 71.9
  TOP w0.102: v2(79.38,84.18) 79.42,84.18 U2.C8
  TOP w0.121: v1(65.57,85.76) 65.57,85.64 65.18,85.25 57.44,85.25 56.68,86.02 55.84,86.02 55.03,85.2 53.43,85.2 52.94,85.7 46.05,85.7 43.94,83.58 43.94,83.51 v1(43.62,83.2)
  BOTTOM w0.121: v1(43.62,83.2) 43.62,82.51 41.19,80.07 41.19,78.42 40.5,77.74 40.5,71.36 46.54,65.32 46.54,57.11 47.61,56.04 J9.13 ; v2(79.38,84.18) 78.99,84.18 78.6,83.79 75.79,83.79 74.33,85.25 71.67,85.25 71.29,85.63 66.27,85.63 66.14,85.76 v1(65.57,85.76)
AM335X_AIN5: length 77.7
  TOP w0.102: 77.1,84.13 78.38,84.13 78.71,83.8 U2.B8
  TOP w0.121: v1(72.43,85.76) 73.44,85.76 73.81,85.39 74.41,85.39 75.42,84.38 76.29,84.38 76.54,84.13 77.1,84.13 ; v1(64.68,88.13) 64.21,87.67 59.22,87.67 58.55,88.34 43.47,88.34 43.28,88.53 v1(42.84,88.53)
  BOTTOM w0.121: J9.15 47.33,54.77 45.86,56.25 45.86,64.93 40,70.79 40,77.94 40.02,77.95 40.02,78.07 40.4,78.45 40.4,80.61 42.84,83.04 v1(42.84,88.53) ; v1(72.43,85.76) 71.99,85.76 71.86,85.89 69.13,85.89 67.39,87.62 67.37,87.62 67.26,87.74 65.08,87.74 v1(64.68,88.13)
AM335X_AIN6: length 60.1
  TOP w0.095: 49.19,54.14 50.58,54.14 50.71,54.01
  TOP w0.102: 77.1,83.8 U2.A8
  TOP w0.121: v1(58.38,51.45) 52.39,51.45 51.73,52.11 51.73,53 50.71,54.01 ; v1(68.11,83.86) 68.42,84.17 69.82,84.17 70.14,84.49 70.14,84.87 70.39,85.12 74.33,85.12 75.31,84.13 76.18,84.13 76.52,83.8 77.1,83.8 ; 49.19,54.14 J9.17
  BOTTOM w0.121: v1(58.38,51.45) 58.38,55.84 62.08,59.54 62.08,66.78 65.19,69.89 65.19,71.65 65.96,72.42 65.96,73.12 67.03,74.2 67.6,74.2 67.86,74.46 67.86,74.84 67.61,75.08 67.61,83.36 v1(68.11,83.86)
AM335X_AIN7: length 210.2
  TOP w0.102: v2(79.4,85) U2.C9
  TOP w0.121: v1(83.46,151.26) 95.25,151.26 95.72,150.79 109.79,150.79 111.72,152.72 116.93,152.72 v1(118.2,153.99) ; R571.2 v1(129.45,160.13) 129.48,160.13 R23.1 ; v1(42.38,85.76) 42.38,86.2 44.27,88.09 57.97,88.09 59.03,87.03 64.2,87.03 65.19,88.02 65.19,88.3 65.19,88.31 65.19,88.94 65.46,89.21 65.63,89.21 65.86,89.44 65.87,89.44 66.12,89.7 66.54,89.7 66.67,89.57 67.01,89.57 67.14,89.7 67.56,89.7 67.85,89.4 67.85,87.04 68.49,86.4 71.67,86.4 71.68,86.41 71.68,86.41 72.05,86.78 74.52,86.78 74.65,86.65 75.48,86.65 75.81,86.32 v1(75.81,85.32)
  LY3 w0.133: v1(129.45,160.13) 123.3,153.99 v1(118.2,153.99)
  LY4 w0.102: v2(79.4,85) 77.1,87.3 77.1,87.67
  LY4 w0.133: v1(83.46,151.26) 82.32,150.11 82.32,145.52 82.49,145.35 82.49,135.93 80.89,134.33 80.89,121.27 73.16,113.55 73.16,103.39 73,103.22 73,101.7 72.74,101.44 72.74,101.07 73.16,100.65 73.16,93.2 74.51,91.86 74.51,90.26 77.1,87.67
  BOTTOM w0.102: 77.84,84.95 77.84,84.96 78.61,84.96 78.67,85.03 79.01,85.03 79.03,85 v2(79.4,85)
  BOTTOM w0.121: v1(75.81,85.32) 76.17,84.95 77.84,84.95 ; v1(42.38,85.76) 42.38,83.07 38.83,79.52 38.83,70.41 44.36,64.88 44.36,55.58 47.7,52.23 J9.19
AM335X_DDR_A0: length 9.4
  TOP w0.102: U2.F3 v2(81.8,79.4)
  BOTTOM w0.102: 80.11,77.4 81.8,79.09 v2(81.8,79.4)
  BOTTOM w0.121: 80.11,77.4 79.25,76.55 78.5,76.55 78.1,76.15 78.1,73.21 R18.1
AM335X_DDR_A1: length 6
  TOP w0.102: U2.H1 83.8,77.4
  TOP w0.121: 83.8,77.4 83.8,76.83 83.8,76.62 83.67,76.49 83.22,76.49 83.1,76.36 83.1,75.67 83.54,75.22 83.54,73.51 83.16,73.13 R21.1
AM335X_DDR_A2: length 10.5
  TOP w0.102: U2.E4 v2(81,80.2)
  BOTTOM w0.102: 79.56,77.4 81.38,79.22 81.38,79.56 81,79.94 v2(81,80.2)
  BOTTOM w0.121: 79.56,77.4 78.96,76.81 78.39,76.81 77.86,76.27 77.86,73.92 R31.1
AM335X_DDR_A3: length 7.7
  TOP w0.102: v2(79.4,79.4) U2.C3
  BOTTOM w0.102: 77.33,79.87 78.93,79.87 v2(79.4,79.4)
  BOTTOM w0.121: 77.33,79.87 77.19,79.73 77.19,78.98 76.93,78.72 76.56,78.72 75.87,79.41 75.15,79.41 R33.1
AM335X_DDR_A4: length 8.4
  TOP w0.102: 79.85,78.95 80.13,78.67 80.13,77.91 79.62,77.4
  TOP w0.121: R34.1 76.75,74.15 77.07,74.15 77.81,74.89 77.81,75.22 79.22,76.63 79.22,77 79.62,77.4 ; U2.C2 79.85,78.95
AM335X_DDR_A5: length 7.3
  TOP w0.102: U2.B1 79,77.97 78.98,77.94
  TOP w0.121: 78.98,77.94 78.68,77.65 78.67,77.65 78.26,77.25 75.37,77.25 74.19,76.06 74.19,75.97 73.19,74.97
AM335X_DDR_A6: length 13.3
  TOP w0.305: v2(80.2,81) U2.D5
  BOTTOM w0.102: v2(80.2,81) 80.2,80.97 80.62,80.56 80.62,79.22 79.09,77.7 77.1,77.7
  BOTTOM w0.121: 77.1,77.7 75.79,77.7 74.78,76.68 R36.1
AM335X_DDR_A7: length 7.6
  TOP w0.102: 81.57,77.55 81.78,77.76 81.78,78.63 81.41,79 U2.E2
  TOP w0.121: R37.1 79.29,75.15 80.43,76.3 80.43,76.68 80.56,76.81 81.44,76.81 81.57,76.94 81.57,77.55
AM335X_DDR_A8: length 9.7
  TOP w0.102: v1(80.2,80.2) U2.D4
  BOTTOM w0.102: 77.1,78.54 78.13,79.56 78.7,79.56 79.24,79.02 80.07,79.02 80.2,79.15 v1(80.2,80.2)
  BOTTOM w0.121: 77.1,78.54 77.03,78.47 75.68,78.47 74.65,77.44 R38.1
AM335X_DDR_A9: length 8
  TOP w0.121: R39.1 76.08,74.43 76.95,74.43 77.53,75.02 77.53,75.29 78.97,76.73 78.97,77.1 79.8,77.93 U2.C1
AM335X_DDR_A10: length 10.2
  TOP w0.102: U2.F4 v2(81.8,80.2)
  BOTTOM w0.102: 80.51,77.4 82.21,79.09 82.21,79.79 81.8,80.2 v2(81.8,80.2)
  BOTTOM w0.121: R40.1 78.4,73.19 78.4,75.86 78.84,76.3 79.36,76.3 80.46,77.4 80.51,77.4
AM335X_DDR_A11: length 7
  TOP w0.102: U2.F2 82.24,79 82.58,78.66 82.58,77.63 82.22,77.27
  TOP w0.121: R41.1 81,73.32 81,73.58 81.06,73.64 81.06,74.01 81,74.07 81,75.35 81.31,75.67 81.51,75.67 81.63,75.79 81.63,76.17 82.22,76.76 82.22,77.27
AM335X_DDR_A12: length 9.8
  TOP w0.102: v2(81,79.4) U2.E3
  BOTTOM w0.102: v2(81,79.4) 81,79.29
  BOTTOM w0.121: R42.1 77.6,74.62 77.6,76.52 78.14,77.06 78.81,77.06 81,79.25 81,79.29
AM335X_DDR_A13: length 5.2
  TOP w0.102: U2.H3 v2(83.4,79.4)
  BOTTOM w0.102: v2(83.4,79.4) 83.4,78.9 81.9,77.4
  BOTTOM w0.121: R43.1 81.19,76.69 81.9,77.4
AM335X_DDR_A14: length 5.9
  TOP w0.102: v2(83.4,80.2) U2.H4
  BOTTOM w0.102: 82.54,77.4 83.79,78.65 83.79,79.79 83.4,80.19 v2(83.4,80.2)
  BOTTOM w0.121: 82.54,77.4 82.14,77 R44.1
AM335X_DDR_BA0: length 6.3
  TOP w0.102: U2.C4 v1(79.4,80.2)
  BOTTOM w0.102: v1(79.4,80.2) 77.29,80.2 77.2,80.1
  BOTTOM w0.121: R47.1 74.45,79.65 76.27,79.65 76.46,79.85 76.94,79.85 77.2,80.1
AM335X_DDR_BA1: length 6.5
  TOP w0.102: U2.E1 81.4,77.78 80.68,77.06 80.45,77.06 80.18,76.78 80.18,76.67
  TOP w0.121: 80.18,76.67 80.18,76.4 79.04,75.26 78.93,75.14 78.93,74.67 78.33,74.08 R49.1
AM335X_DDR_BA2: length 7.7
  TOP w0.102: 77.1,77.49 78.09,77.49 78.59,77.99 78.59,79.11 79,79.52 U2.B3
  TOP w0.121: R549.1 74.11,77.13 74.48,77.49 77.1,77.49
AM335X_DDR_CASN: length 6.4
  TOP w0.102: U2.F1 82.2,77.76 81.84,77.4
  TOP w0.121: R13.1 80.17,73.19 80.17,75.48 80.68,75.98 80.68,76.43 80.81,76.55 81.67,76.55 81.84,76.73 81.84,77.4
AM335X_DDR_CKE: length 5.7
  TOP w0.102: U2.G3 v2(82.6,79.4)
  BOTTOM w0.102: 80.97,77.4 82.6,79.03 v2(82.6,79.4)
  BOTTOM w0.121: R537.1 80.87,77.25 80.87,77.3 80.97,77.4
AM335X_DDR_CLK: length 8
  TOP w0.095: R11.1 77.38,73.63 78.5,74.75 78.5,75.12 79.92,76.54 79.92,76.85 80.89,77.81 80.89,77.92 81,78.03 81,78.9 80.9,79 U2.D2
AM335X_DDR_CLKN: length 7.1
  TOP w0.095: R12.1 77.1,73.54 77.1,73.75 78.22,74.87 78.22,75.24 79.64,76.66 79.64,76.97 80.6,77.93 U2.D1
AM335X_DDR_CSN: length 6.6
  TOP w0.102: 84.32,77.04 84.32,77.42 84.17,77.57 84.17,78.65 83.82,79 U2.H2
  TOP w0.121: R538.1 84.56,73.63 84.56,75.16 84.05,75.67 84.05,76.3 84.17,76.43 84.19,76.43 84.32,76.55 84.32,77.04
AM335X_DDR_D0: length 6.7
  TOP w0.102: v2(87.4,79.4) U2.M3
  BOTTOM w0.102: 87.4,77.4 v2(87.4,79.4)
  BOTTOM w0.121: R429.1 87.72,73.65 87.72,76.39 87.4,76.71 87.4,77.4
AM335X_DDR_D1: length 9
  TOP w0.102: v2(87.4,80.2) U2.M4
  BOTTOM w0.102: v2(87.4,80.2) 87.4,80.19 87.79,79.79 87.79,77.63 88.03,77.4
  BOTTOM w0.121: R522.1 88.94,74.33 89.83,75.22 89.83,76.14 89.1,76.87 88.56,76.87 88.03,77.4
AM335X_DDR_D2: length 7.7
  TOP w0.102: 87.96,77.4 87.8,77.56 U2.N1
  TOP w0.121: R523.1 91.67,73.7 91.6,73.76 91.6,75.45 90.92,76.14 90.62,76.14 90.1,76.65 89.64,76.65 89.18,77.11 88.25,77.11 87.96,77.4
AM335X_DDR_D3: length 9.1
  TOP w0.102: U2.N2 87.8,78.74 88.26,78.28 ; 88.26,78.06 88.26,77.86 88.72,77.4
  TOP w0.121: 88.26,78.06 88.26,78.28 ; R524.1 91.91,73.84 91.91,76.34 91.78,76.47 90.64,76.47 90.21,76.9 89.74,76.9 89.28,77.36 88.76,77.36 88.72,77.4
AM335X_DDR_D4: length 8.1
  TOP w0.102: U2.N3 v2(88.2,79.4)
  BOTTOM w0.102: v2(88.2,79.4) 88.2,78.18 88.98,77.4
  BOTTOM w0.121: 88.98,77.4 90.08,76.3 90.08,74.77 90.71,74.13 90.71,73.45 R525.1
AM335X_DDR_D5: length 5.7
  TOP w0.102: U2.N4 v2(88.2,80.2)
  BOTTOM w0.102: 89.62,77.4 88.58,78.43 88.58,79.58 88.2,79.96 v2(88.2,80.2)
  BOTTOM w0.121: R526.1 90.72,76.3 89.62,77.4
AM335X_DDR_D6: length 8.2
  TOP w0.305: U2.P3 v2(89,79.4)
  BOTTOM w0.102: v2(89,79.4) 89,78.52 90.12,77.4
  BOTTOM w0.121: R527.1 92.24,73.44 91.41,74.27 91.41,76.18 90.58,77.01 90.52,77.01 90.12,77.4
AM335X_DDR_D7: length 10.1
  TOP w0.102: U2.P4 v2(89,80.2)
  BOTTOM w0.102: v2(89,80.2) 89.04,80.2 89.42,79.82 89.42,78.61 90.63,77.4
  BOTTOM w0.121: R528.1 91.86,74.33 91.86,76.75 91.35,77.25 90.78,77.25 90.63,77.4
AM335X_DDR_D8: length 5.3
  TOP w0.102: U2.J1 84.6,77.62 84.59,77.61 84.59,77.53 84.56,77.5 84.56,77.13 84.62,77.07
  TOP w0.121: 84.62,77.07 84.62,76.05 85,75.67 R529.1
AM335X_DDR_D9: length 5.3
  TOP w0.102: 85.7,77.06 85.7,77.66 85.4,77.96 U2.K1
  TOP w0.121: R530.1 85.95,73.63 85.7,73.89 85.7,77.06
AM335X_DDR_D10: length 6.5
  TOP w0.102: U2.K2 85.41,79 85.83,78.59 85.83,77.82 85.96,77.69 85.96,77.28 85.96,77.26
  TOP w0.121: 85.96,77.26 85.96,76.61 86.34,76.23 86.34,73.82 86.91,73.25 R531.1
AM335X_DDR_D11: length 5.4
  TOP w0.102: v2(85.8,79.4) U2.K3
  BOTTOM w0.102: v2(85.8,79.4) 85.76,79.36 85.76,77.53 85.64,77.4 85.57,77.4 85.44,77.27 85.44,76.94 85.31,76.81 84.81,76.81
  BOTTOM w0.121: 84.81,76.81 84.05,76.05 R532.1
AM335X_DDR_D12: length 5.4
  TOP w0.102: U2.K4 v2(85.8,80.2)
  BOTTOM w0.102: 85.95,77.4 85.95,77.43 85.97,77.44 85.97,78.79 86.21,79.03 86.21,79.86 85.86,80.2 v2(85.8,80.2)
  BOTTOM w0.121: 85.95,77.4 R533.1
AM335X_DDR_D13: length 4.4
  TOP w0.102: v2(86.6,79.4) U2.L3
  BOTTOM w0.102: v2(86.6,79.4) 86.6,77.4
  BOTTOM w0.121: R534.1 86.6,75.97 86.6,77.4
AM335X_DDR_D14: length 8.1
  TOP w0.102: U2.L4 v2(86.6,80.2)
  BOTTOM w0.102: v2(86.6,80.2) 86.83,80.2 86.98,80.05 86.98,77.4
  BOTTOM w0.121: R535.1 87.41,73.95 87.41,76.24 87.28,76.36 87.11,76.36 86.98,76.49 86.98,77.4
AM335X_DDR_D15: length 6.7
  TOP w0.102: 87,77.4 U2.M1
  TOP w0.121: R536.1 89.76,73.57 89.38,73.95 88.53,73.95 87.44,75.03 87.44,76.9 87,77.35 87,77.4
AM335X_DDR_DQM0: length 8.8
  TOP w0.102: U2.M2 87.27,79 87.39,78.87 87.39,77.4
  TOP w0.121: 87.39,77.4 87.79,77 87.79,75.9 87.79,75.86 87.79,75.26 87.79,75.22 88.43,74.59 90.46,74.59 90.72,74.33 R16.1
AM335X_DDR_DQM1: length 3.9
  TOP w0.102: U2.J2 84.6,78.99 85,78.59 85,78.02 85.25,77.76 85.31,77.76 85.44,77.63 85.44,77.13 85.25,76.95
  TOP w0.121: 85.25,76.95 v1(85.25,76.3)
  BOTTOM w0.121: R19.1 85,76.05 v1(85.25,76.3)
AM335X_DDR_DQS0: length 11.4
  TOP w0.102: 88.6,77.91 U2.P1
  TOP w0.121: 88.6,77.91 88.9,77.61 89.38,77.61 89.85,77.15 90.31,77.15 90.66,76.8 92.04,76.8 92.24,76.59 92.24,74.23 92.37,74.1 94.63,74.1 94.75,73.98 94.75,73.27 94.63,73.14 93.59,73.14 R17.1
AM335X_DDR_DQS1: length 6.5
  TOP w0.102: 86.2,77.6 U2.L1
  TOP w0.121: 86.2,77.6 86.2,77.38 86.21,77.37 86.21,76.74 86.59,76.36 86.59,74.33 86.84,74.08 87.67,74.08 88.11,73.63 88.11,73.25 87.98,73.13 R20.1
AM335X_DDR_DQSN0: length 11.3
  TOP w0.102: 89.11,77.97 89.06,78.02 89.06,78.53 88.6,78.99 U2.P2
  TOP w0.121: 89.11,77.97 89.22,77.86 89.49,77.86 89.95,77.4 90.41,77.4 90.69,77.12 94.44,77.12 95.31,76.24 95.31,75.38 95.31,75.07 95.48,74.9 R539.1
AM335X_DDR_DQSN1: length 7.4
  TOP w0.102: 86.6,77.4 86.59,77.41 86.59,78.59 86.2,78.97 U2.L2
  TOP w0.121: 86.6,77.4 86.6,76.74 86.91,76.43 86.91,74.71 87.16,74.46 87.67,74.46 88.37,73.76 88.37,73.25 88.49,73.13 R540.1
AM335X_DDR_RASN: length 6.4
  TOP w0.102: U2.G4 v2(82.6,80.2)
  BOTTOM w0.102: v2(82.6,80.2) 82.62,80.2 82.98,79.84 82.98,79.09 81.83,77.94 81.83,77.82 81.4,77.4
  BOTTOM w0.121: 81.4,77.4 80.24,76.24 R14.1
AM335X_DDR_WEN: length 10.5
  TOP w0.102: 78.77,77.4 79.38,78.01 79.38,78.87 79.25,79 U2.B2
  TOP w0.121: R15.1 74.44,73.74 74.44,75.96 75.48,77 78.37,77 78.77,77.4
AM335X_DDRODT: length 5.8
  TOP w0.102: U2.G1 83,77.82 82.97,77.79 82.97,77.13 82.84,77 82.71,77
  TOP w0.121: R543.1 82.14,73.44 81.95,73.63 81.95,75.48 82.14,75.67 82.46,75.67 82.59,75.79 82.59,76.87 82.71,77
AM335X_ECAP0_IN_PWM0_OUT: length 46.3
  TOP w0.121: v1(79.89,97.01) 79.89,96.91 80.49,96.31 80.49,95.04 80.24,94.79 80.24,92.24 U2.C18 ; R255.2 73.81,132.77 75.53,132.77 v1(75.92,133.16)
  BOTTOM w0.121: v1(79.89,97.01) 79.89,97.14 79.74,97.28 79.74,102.96 79.08,103.62 79.08,105.28 79.08,105.64 79.02,105.71 79.02,106.42 79.02,106.89 78.39,107.51 78.39,120.03 76.42,122 76.42,123.53 75.81,124.14 75.81,128.91 75.73,128.99 75.73,132.96 v1(75.92,133.16)
AM335X_EXT_WAKEUP: length 155.2
  TOP w0.102: 77.1,80.56 77.6,80.56 77.89,80.27 78.34,80.27 78.53,80.46 78.53,80.6 78.93,81 79.4,81 U2.C5
  TOP w0.121: v1(75.63,144.69) 74.36,145.96 67.08,145.96 v1(65.94,147.1) ; v1(67.17,74.69) 67.75,74.69 68.54,75.48 68.54,78.46 68.68,78.59 68.68,78.68 68.9,78.91 70.68,78.91 71.05,79.28 71.4,79.28 71.79,79.67 75.48,79.67 76.36,80.56 77.1,80.56 ; v1(62.29,68.36) 61.84,68.82 41.1,68.82 36.01,63.73 35.16,63.73 34.67,63.24 34.53,63.24 34.17,62.89 34.17,62.42 R405.2
  BOTTOM w0.121: v1(75.63,144.69) 76.11,144.21 R207.2 ; v1(62.29,68.36) 63.38,69.46 63.38,70.51 65.7,72.82 65.7,73.21 v1(67.17,74.69) 67.17,78.07 64.81,80.43 64.81,82.08 64.43,82.46 64.43,83.63 63.72,84.33 63.72,87.35 63.03,88.05 63.03,92.62 63.09,92.68 63.09,97.76 63.41,98.08 64.05,98.08 64.68,98.72 64.68,101.16 64.47,101.38 64.47,102.15 64.68,102.36 64.68,111.8 59.85,116.62 59.85,120.56 58.39,122.02 58.39,129.64 57.95,130.09 57.95,134.91 57.31,135.55 57.31,140.37 57.7,140.75 59.47,140.75 61.76,143.04 61.76,145.2 63.66,147.1 v1(65.94,147.1)
AM335X_EXTINTN: length 131.6
  TOP w0.102: 79.72,92.9 79.72,92.65 79,91.93 U2.B18
  TOP w0.121: v1(34.71,62.8) 34.81,62.8 R479.2 ; v1(9.14,62.1) 9.14,51.43 v1(6.9,49.19) ; 79.72,92.9 79.72,93.99 79.07,94.64 77.57,94.64 76.63,95.58 73.59,95.58 73.06,95.05 72.45,95.05 72.04,95.05 71.34,95.75 70.94,95.75 69.58,97.1 66.27,97.1 65.41,97.1 64.81,96.5 61.96,96.5 61.86,96.4 R324.2 61.35,95.9 61.25,95.8 59.93,95.8 59.65,95.52 57.73,95.52 55.81,93.6 48.01,93.6 47.09,92.69 39.54,92.69 38.52,93.71 34.92,93.71 34.73,93.52 v1(34.73,93.08)
  LY3 w0.133: v1(34.71,62.8) 34.01,62.1 v1(9.14,62.1)
  BOTTOM w0.121: v1(34.73,93.08) 35.3,92.51 35.3,88.3 28.78,81.78 28.78,67.23 32.22,63.79 33.72,63.79 v1(34.71,62.8) ; 6.9,47.28 v1(6.9,49.19)
AM335X_GMII1_COL: length 16.5
  TOP w0.102: v2(83.4,90.6) U2.H16
  TOP w0.121: v1(82.46,102.42) 82.13,102.1 82.13,102.04 R66.2
  LY4 w0.102: v2(83.4,90.6) 83.61,90.81 83.61,92.9
  LY4 w0.121: 83.6,101.76 83.12,101.76 v1(82.46,102.42)
  LY4 w0.133: 83.61,92.9 83.61,93.64 83.27,93.98 83.27,97.62 83.69,98.05 83.69,100.02 84.03,100.37 84.59,100.37 84.94,100.71 84.94,101.31 84.94,101.32 84.94,101.32 84.49,101.76 83.6,101.76
AM335X_GMII1_CRS: length 77
  TOP w0.102: 83.54,92.9 83.47,92.83 83.47,91.36 83.8,91.03 U2.H17
  TOP w0.121: R235.2 53.25,133.09 53.56,132.78 53.56,132.67 54.65,131.58 54.65,130.38 55.7,129.34 60.47,129.34 60.82,129.69 65.65,129.69 66.01,129.33 66.67,129.33 76.37,129.33 76.44,129.26 76.8,129.26 76.86,129.33 81.73,129.33 83.58,131.18 v1(84.09,131.18) ; 83.54,92.9 83.54,94.61 83.46,94.7 83.46,96.18 82.91,96.72 82.91,98.34 82.38,98.86 v1(82.38,99.55)
  BOTTOM w0.121: v1(84.09,131.18) 83.8,130.89 83.8,121.9 82.26,120.36 82.26,119.85 81,118.59 81,106.77 81.71,106.07 81.71,101.2 81.98,100.93 81.98,99.96 v1(82.38,99.55)
AM335X_GMII1_MDIO_CLK: length 10.8
  TOP w0.102: U2.M18 v2(87,92.56)
  TOP w0.121: v1(90.4,95.54) 90.59,95.73 90.59,96.94 R433.2
  LY4 w0.102: 86.66,92.9 v2(87,92.56)
  LY4 w0.121: 86.66,93.61 86.66,92.9 ; v1(90.4,95.54) 90.07,95.86
  LY4 w0.133: 86.66,93.61 86.66,94.33 87.18,94.86 87.18,96.07 87.82,96.71 89.23,96.71 90.07,95.86
AM335X_GMII1_MDIO_DATA: length 13.8
  TOP w0.102: U2.M17 87.38,91.38 87.38,92.87 87.35,92.9
  TOP w0.121: 87.35,92.9 87.35,93.64 v1(87.16,93.83) ; v1(93.64,99.99) 93.51,99.86 R434.2
  LY3 w0.133: v1(87.16,93.83) 87.66,93.83 89.31,95.48 89.31,97.05 90.53,98.27 91.03,98.27 91.99,99.22 92.87,99.22 v1(93.64,99.99)
AM335X_GMII1_REFCLK: length 54.3
  TOP w0.102: U2.H18 83.8,92.89 83.79,92.9
  TOP w0.121: v1(93.94,131.3) 93.81,131.43 89.9,131.43 88.24,129.77 v1(85.71,129.77) ; 83.79,92.9 83.79,93.25 83.8,93.26 83.8,94.73 83.7,94.83 83.7,96.28 83.16,96.83 83.16,100.09 83.6,100.54 83.6,104.05 83.73,104.18 83.73,107.74 82.59,108.88 v1(82.21,108.88) R432.2
  BOTTOM w0.121: v1(85.71,129.77) 86.2,129.28 86.2,124.55 85.23,123.58 85.23,122.11 83.83,120.71 83.83,118.8 83.08,118.06 83.08,115.48 81.76,114.16 81.76,109.32 v1(82.21,108.88) ; R410.1 93.39,133.39 93.39,131.86 v1(93.94,131.3)
AM335X_GMII1_RXCLK: length 142.9
  TOP w0.102: 86.2,92.9 U2.L18
  TOP w0.121: v1(86.27,115.56) 85.6,115.56 85.49,115.45 83.27,115.45 82.74,114.91 60.23,114.91 59.73,114.42 57.24,114.42 56.96,114.69 52.75,114.69 52.52,114.92 52.26,114.92 52.04,114.69 v1(50.1,114.69) ; v1(85.86,103.67) 85.86,103.18 86.48,102.56 86.48,100.59 86.85,100.21 86.85,97.22 85.76,96.13 85.76,94.73 85.76,94.47 86.2,94.04 86.2,92.9 ; v1(42.05,58.94) 42.05,58.09 R423.2
  BOTTOM w0.121: v1(42.05,58.94) 42.46,59.35 42.46,64.05 42.31,64.19 42.31,64.48 42.3,64.49 42.3,64.69 37.34,69.65 37.31,69.65 37.31,80.15 40.48,83.32 40.48,84.52 40.77,84.82 40.77,84.95 40.77,94.65 41.46,95.34 41.46,97.93 43.04,99.51 43.04,107.88 45.08,109.92 45.08,110.09 44.42,110.75 44.42,110.92 44.59,111.09 44.76,111.09 45.42,110.43 45.59,110.43 45.76,110.6 45.76,110.77 45.11,111.43 45.11,111.6 45.28,111.77 45.45,111.77 46.1,111.12 46.27,111.12 46.45,111.29 46.45,111.46 45.79,112.11 45.79,112.29 45.96,112.46 46.13,112.46 46.79,111.8 46.96,111.8 47.79,112.63 48.62,112.63 50.1,114.11 v1(50.1,114.69) ; v1(85.86,103.67) 85.86,115.2 85.64,115.42 85.64,119.93 85.77,120.05 86.32,120.05 86.45,119.93 86.45,116.85 86.32,116.72 86.08,116.72 85.96,116.6 85.96,115.87 v1(86.27,115.56)
AM335X_GMII1_RXD0: length 143.3
  TOP w0.102: v2(87.4,90.6) U2.M16
  TOP w0.121: R424.2 v1(41.49,56.15) ; v1(49.14,114.49) 49.14,114.05 49.4,113.79 50.49,113.79 50.7,114 56.71,114 56.96,113.75 60.79,113.75 61.28,114.24 83.63,114.24 83.83,114.03 87.11,114.03 87.23,114.15 87.23,115.05 87.35,115.18 87.59,115.18 87.71,115.05 87.71,114.15 87.83,114.03 88.07,114.03 88.2,114.15 88.2,115.51 88.32,115.63 88.55,115.63 88.68,115.51 88.68,114.15 88.8,114.03 88.91,114.03 89.67,113.27 90.63,113.27 v1(91.41,112.49)
  BOTTOM w0.102: v2(87.4,90.6) 87.4,91.26 87.87,91.73 87.87,92.9
  BOTTOM w0.121: v1(41.49,56.15) 41.18,56.46 41.18,56.57 40.65,57.1 40.65,59.49 40.92,59.76 40.92,64.28 36.21,69 36.21,80.61 39.09,83.49 39.09,84.09 39.09,84.81 39.67,85.4 39.67,97.7 39.69,97.71 39.94,97.97 41.88,99.91 41.88,100.97 41.88,109.35 42.7,110.18 42.7,112.28 43.98,113.55 48.2,113.55 49.14,114.49 v1(49.14,114.49) ; v1(91.41,112.49) 91.41,109.2 92.49,108.11 92.49,102.88 91.27,101.66 91.27,100.29 90.84,99.86 90.84,97.34 89.75,96.25 89.75,96.22 87.87,94.35 87.87,92.9
AM335X_GMII1_RXD1: length 143.5
  TOP w0.102: v2(86.6,89.8) U2.L15
  TOP w0.121: R425.2 42.56,54.27 42.81,54.51 v1(42.81,54.57) ; v1(48.6,110.66) 50.33,110.66 50.79,111.12 65,111.12 65.2,111.32 79.65,111.32 80.06,110.91 86.9,110.91 87.08,111.1 87.87,111.1 87.94,111.16 v1(88,111.16)
  BOTTOM w0.102: 85.94,92.9 85.94,92.09 85.33,91.48 85.33,90.49 85.64,90.18 86.3,90.18 86.6,89.88 v2(86.6,89.8)
  BOTTOM w0.121: v1(42.81,54.57) 42.81,55.18 43.42,55.79 43.42,64.62 37.98,70.06 37.98,79.87 41.45,83.34 41.45,94.27 42.4,95.23 42.4,97.93 43.71,99.23 43.71,107.6 43.88,107.77 44.05,107.77 44.83,107 45,107 45.17,107.17 45.17,107.34 44.4,108.12 44.4,108.29 44.57,108.46 44.74,108.46 45.51,107.68 45.68,107.68 45.85,107.85 45.85,108.02 45.08,108.8 45.08,108.97 45.25,109.14 45.42,109.14 46.19,108.37 46.36,108.37 46.53,108.54 46.53,108.71 45.76,109.48 45.76,109.65 45.93,109.82 46.1,109.82 46.88,109.05 47.05,109.05 47.22,109.22 47.22,109.39 46.44,110.16 46.44,110.33 46.61,110.5 46.79,110.5 47.56,109.73 47.73,109.73 47.9,109.9 47.9,110.07 47.13,110.85 47.13,111.02 47.98,111.87 48.47,111.87 48.93,111.42 48.93,111.06 48.91,111.04 48.91,110.98 v1(48.6,110.66) ; v1(88,111.16) 88,110.68 88.18,110.5 88.18,109.71 88.3,109.59 88.56,109.59 88.68,109.46 88.68,107.1 87.9,106.31 87.9,99.5 87.25,98.85 87.25,95.93 87.17,95.85 87.17,94.92 86.33,94.07 86.33,93.95 85.94,93.56 85.94,92.9
